$ Spice netlist generated by v2lvs
$ v2012.2_26.20    Thu Jun 14 12:01:04 PDT 2012
.INCLUDE "RF2SH64x16.spi"
.INCLUDE "tpz013g3_lvs.spi"
.INCLUDE "tsmc13gfsg_fram_lvs.spi"

.SUBCKT DataMemory_test_1 clk rst stall EX_WB[1] EX_WB[0] EX_MEM[2] EX_MEM[1]
+ EX_MEM[0] EX_ALUresult[31] EX_ALUresult[30] EX_ALUresult[29] EX_ALUresult[28]
+ EX_ALUresult[27] EX_ALUresult[26] EX_ALUresult[25] EX_ALUresult[24]
+ EX_ALUresult[23] EX_ALUresult[22] EX_ALUresult[21] EX_ALUresult[20]
+ EX_ALUresult[19] EX_ALUresult[18] EX_ALUresult[17] EX_ALUresult[16]
+ EX_ALUresult[15] EX_ALUresult[14] EX_ALUresult[13] EX_ALUresult[12]
+ EX_ALUresult[11] EX_ALUresult[10] EX_ALUresult[9] EX_ALUresult[8]
+ EX_ALUresult[7] EX_ALUresult[6] EX_ALUresult[5] EX_ALUresult[4]
+ EX_ALUresult[3] EX_ALUresult[2] EX_ALUresult[1] EX_ALUresult[0]
+ EX_RegisterRd[4] EX_RegisterRd[3] EX_RegisterRd[2] EX_RegisterRd[1]
+ EX_RegisterRd[0] MEMWriteData[31] MEMWriteData[30] MEMWriteData[29]
+ MEMWriteData[28] MEMWriteData[27] MEMWriteData[26] MEMWriteData[25]
+ MEMWriteData[24] MEMWriteData[23] MEMWriteData[22] MEMWriteData[21]
+ MEMWriteData[20] MEMWriteData[19] MEMWriteData[18] MEMWriteData[17]
+ MEMWriteData[16] MEMWriteData[15] MEMWriteData[14] MEMWriteData[13]
+ MEMWriteData[12] MEMWriteData[11] MEMWriteData[10] MEMWriteData[9]
+ MEMWriteData[8] MEMWriteData[7] MEMWriteData[6] MEMWriteData[5]
+ MEMWriteData[4] MEMWriteData[3] MEMWriteData[2] MEMWriteData[1]
+ MEMWriteData[0] WB[1] WB[0] MemoryData[31] MemoryData[30] MemoryData[29]
+ MemoryData[28] MemoryData[27] MemoryData[26] MemoryData[25] MemoryData[24]
+ MemoryData[23] MemoryData[22] MemoryData[21] MemoryData[20] MemoryData[19]
+ MemoryData[18] MemoryData[17] MemoryData[16] MemoryData[15] MemoryData[14]
+ MemoryData[13] MemoryData[12] MemoryData[11] MemoryData[10] MemoryData[9]
+ MemoryData[8] MemoryData[7] MemoryData[6] MemoryData[5] MemoryData[4]
+ MemoryData[3] MemoryData[2] MemoryData[1] MemoryData[0] ALUresult[31]
+ ALUresult[30] ALUresult[29] ALUresult[28] ALUresult[27] ALUresult[26]
+ ALUresult[25] ALUresult[24] ALUresult[23] ALUresult[22] ALUresult[21]
+ ALUresult[20] ALUresult[19] ALUresult[18] ALUresult[17] ALUresult[16]
+ ALUresult[15] ALUresult[14] ALUresult[13] ALUresult[12] ALUresult[11]
+ ALUresult[10] ALUresult[9] ALUresult[8] ALUresult[7] ALUresult[6]
+ ALUresult[5] ALUresult[4] ALUresult[3] ALUresult[2] ALUresult[1] ALUresult[0]
+ RegisterRd[4] RegisterRd[3] RegisterRd[2] RegisterRd[1] RegisterRd[0]
+ read_MemoryData[31] read_MemoryData[30] read_MemoryData[29]
+ read_MemoryData[28] read_MemoryData[27] read_MemoryData[26]
+ read_MemoryData[25] read_MemoryData[24] read_MemoryData[23]
+ read_MemoryData[22] read_MemoryData[21] read_MemoryData[20]
+ read_MemoryData[19] read_MemoryData[18] read_MemoryData[17]
+ read_MemoryData[16] read_MemoryData[15] read_MemoryData[14]
+ read_MemoryData[13] read_MemoryData[12] read_MemoryData[11]
+ read_MemoryData[10] read_MemoryData[9] read_MemoryData[8] read_MemoryData[7]
+ read_MemoryData[6] read_MemoryData[5] read_MemoryData[4] read_MemoryData[3]
+ read_MemoryData[2] read_MemoryData[1] read_MemoryData[0] test_si test_so
+ test_se SPCASCAN_N6 FE_PT1_ICACHE_addr_i_25_ SPCASCAN_N10
+ FE_PT1_ICACHE_addr_i_23_ SPCASCAN_N30 SPCASCAN_N31 SPCASCAN_N32 SPCASCAN_N33
+ SPCASCAN_N34 SPCASCAN_N35 SPCASCAN_N36 SPCASCAN_N37 FE_OFN14_test_se_i
+ FE_OFN18_test_se_i FE_OFN4_test_se_i FE_OFN5_test_se_i FE_OFN8_test_se_i
+ SPCBSCAN_N41 SPCBSCAN_N42 FE_OFN51_test_se_i FE_OFN53_test_se_i
+ FE_OFN54_test_se_i clk_i__L3_N19 clk_i__L3_N27 clk_i__L3_N9
XFE_OFC169_n149 CLKBUFX3 $PINS Y=FE_OFN169_n149 A=n148
XFE_OFC168_n148 CLKBUFX2 $PINS Y=FE_OFN168_n148 A=n148
XFE_OFC141_n35 CLKBUFX2 $PINS Y=FE_OFN141_n35 A=FE_OFN140_n35
XFE_OFC140_n35 CLKBUFX2 $PINS Y=FE_OFN140_n35 A=n35
XFE_OFC139_n37 CLKBUFX2 $PINS Y=FE_OFN139_n37 A=FE_OFN138_n37
XFE_OFC138_n37 CLKBUFX2 $PINS Y=FE_OFN138_n37 A=n37
XFE_OFC137_n36 CLKBUFX2 $PINS Y=FE_OFN137_n36 A=FE_OFN136_n36
XFE_OFC136_n36 CLKBUFX2 $PINS Y=FE_OFN136_n36 A=n36
XFE_OFC52_test_se_i CLKBUFX2 $PINS Y=FE_OFN52_test_se_i A=FE_OFN51_test_se_i
XFE_OFC25_SPCASCAN_N6 CLKBUFX2 $PINS Y=SPCASCAN_N6 A=FE_OFN25_SPCASCAN_N6
XFE_OFC24_MEM_WB_WBControl_0_ CLKBUFX2 $PINS Y=WB[0]
+ A=FE_OFN24_MEM_WB_WBControl_0_
XU2 CLKBUFX2 $PINS Y=n40 A=stall
XU3 MX2XL $PINS Y=n107 S0=n144 B=RegisterRd[0] A=EX_RegisterRd[0]
XU4 MX2XL $PINS Y=n108 S0=n144 B=RegisterRd[1] A=EX_RegisterRd[1]
XU5 MX2XL $PINS Y=n110 S0=n144 B=RegisterRd[3] A=EX_RegisterRd[3]
XU6 MX2XL $PINS Y=n109 S0=n144 B=RegisterRd[2] A=EX_RegisterRd[2]
XU7 MX2XL $PINS Y=n111 S0=n144 B=RegisterRd[4] A=EX_RegisterRd[4]
XU8 MX2XL $PINS Y=n106 S0=n144 B=WB[1] A=EX_WB[1]
XU9 CLKINVX1 $PINS Y=n36 A=n40
XU10 CLKINVX1 $PINS Y=n37 A=n40
XU12 CLKINVX1 $PINS Y=n35 A=n144
XU16 CLKBUFX3 $PINS Y=n144 A=n40
XU17 CLKBUFX3 $PINS Y=n147 A=n146
XU18 CLKBUFX3 $PINS Y=n148 A=n146
XU20 CLKBUFX3 $PINS Y=n150 A=n146
XU25 CLKBUFX3 $PINS Y=n146 A=rst
XU26 OAI2BB2XL $PINS Y=n112 B1=FE_OFN140_n35 B0=n41 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[0]
XU27 OAI2BB2XL $PINS Y=n113 B1=FE_OFN140_n35 B0=n42 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[1]
XU28 OAI2BB2XL $PINS Y=n114 B1=FE_OFN140_n35 B0=SPCASCAN_N6 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[2]
XU29 OAI2BB2XL $PINS Y=n115 B1=FE_OFN140_n35 B0=n44 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[3]
XU30 OAI2BB2XL $PINS Y=n116 B1=FE_OFN140_n35 B0=n45 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[4]
XU31 OAI2BB2XL $PINS Y=n117 B1=FE_OFN140_n35 B0=n46 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[5]
XU32 OAI2BB2XL $PINS Y=n118 B1=FE_OFN137_n36 B0=n47 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[6]
XU33 OAI2BB2XL $PINS Y=n119 B1=n35 B0=SPCASCAN_N36 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[7]
XU34 OAI2BB2XL $PINS Y=n120 B1=FE_OFN140_n35 B0=n49 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[8]
XU35 OAI2BB2XL $PINS Y=n121 B1=FE_OFN140_n35 B0=n50 A1N=FE_OFN138_n37
+ A0N=EX_ALUresult[9]
XU36 OAI2BB2XL $PINS Y=n122 B1=FE_OFN141_n35 B0=n51 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[10]
XU37 OAI2BB2XL $PINS Y=n123 B1=FE_OFN141_n35 B0=n52 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[11]
XU38 OAI2BB2XL $PINS Y=n124 B1=FE_OFN141_n35 B0=n53 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[12]
XU39 OAI2BB2XL $PINS Y=n125 B1=FE_OFN141_n35 B0=n54 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[13]
XU40 OAI2BB2XL $PINS Y=n126 B1=FE_OFN141_n35 B0=n55 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[14]
XU41 OAI2BB2XL $PINS Y=n127 B1=FE_OFN141_n35 B0=n56 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[15]
XU42 OAI2BB2XL $PINS Y=n128 B1=FE_OFN141_n35 B0=n57 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[16]
XU43 OAI2BB2XL $PINS Y=n129 B1=FE_OFN141_n35 B0=n58 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[17]
XU44 OAI2BB2XL $PINS Y=n130 B1=FE_OFN141_n35 B0=n59 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[18]
XU45 OAI2BB2XL $PINS Y=n131 B1=FE_OFN137_n36 B0=n60 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[19]
XU46 OAI2BB2XL $PINS Y=n132 B1=FE_OFN137_n36 B0=n61 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[20]
XU47 OAI2BB2XL $PINS Y=n133 B1=FE_OFN137_n36 B0=n62 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[21]
XU48 OAI2BB2XL $PINS Y=n134 B1=FE_OFN137_n36 B0=SPCASCAN_N30 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[22]
XU49 OAI2BB2XL $PINS Y=n135 B1=FE_OFN141_n35 B0=SPCASCAN_N32 A1N=FE_OFN139_n37
+ A0N=EX_ALUresult[23]
XU50 OAI2BB2XL $PINS Y=n136 B1=FE_OFN141_n35 B0=SPCBSCAN_N42 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[24]
XU51 OAI2BB2XL $PINS Y=n137 B1=FE_OFN141_n35 B0=n66 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[25]
XU52 OAI2BB2XL $PINS Y=n138 B1=FE_OFN141_n35 B0=n67 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[26]
XU53 OAI2BB2XL $PINS Y=n139 B1=FE_OFN137_n36 B0=n68 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[27]
XU54 OAI2BB2XL $PINS Y=n140 B1=FE_OFN137_n36 B0=n69 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[28]
XU55 OAI2BB2XL $PINS Y=n141 B1=FE_OFN141_n35 B0=n70 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[29]
XU56 OAI2BB2XL $PINS Y=n142 B1=FE_OFN138_n37 B0=n71 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[30]
XU57 OAI2BB2XL $PINS Y=n143 B1=FE_OFN137_n36 B0=SPCASCAN_N34 A1N=FE_OFN137_n36
+ A0N=EX_ALUresult[31]
XU58 OAI2BB2XL $PINS Y=n73 B1=FE_OFN136_n36 B0=n2 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[0]
XU59 OAI2BB2XL $PINS Y=n74 B1=FE_OFN140_n35 B0=n3 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[1]
XU60 OAI2BB2XL $PINS Y=n75 B1=FE_OFN136_n36 B0=n4 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[2]
XU61 OAI2BB2XL $PINS Y=n76 B1=FE_OFN140_n35 B0=n5 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[3]
XU62 OAI2BB2XL $PINS Y=n77 B1=FE_OFN140_n35 B0=n6 A1N=n37
+ A0N=read_MemoryData[4]
XU63 OAI2BB2XL $PINS Y=n78 B1=n36 B0=n7 A1N=n37 A0N=read_MemoryData[5]
XU64 OAI2BB2XL $PINS Y=n79 B1=n36 B0=n8 A1N=n37 A0N=read_MemoryData[6]
XU65 OAI2BB2XL $PINS Y=n80 B1=FE_OFN140_n35 B0=n9 A1N=n37
+ A0N=read_MemoryData[7]
XU66 OAI2BB2XL $PINS Y=n81 B1=FE_OFN140_n35 B0=n10 A1N=n37
+ A0N=read_MemoryData[8]
XU67 OAI2BB2XL $PINS Y=n82 B1=FE_OFN140_n35 B0=n11 A1N=n37
+ A0N=read_MemoryData[9]
XU68 OAI2BB2XL $PINS Y=n83 B1=n36 B0=n12 A1N=n37 A0N=read_MemoryData[10]
XU69 OAI2BB2XL $PINS Y=n84 B1=FE_OFN140_n35 B0=n13 A1N=n37
+ A0N=read_MemoryData[11]
XU70 OAI2BB2XL $PINS Y=n85 B1=FE_OFN141_n35 B0=n14 A1N=FE_OFN138_n37
+ A0N=read_MemoryData[12]
XU71 OAI2BB2XL $PINS Y=n86 B1=FE_OFN141_n35 B0=n15 A1N=FE_OFN139_n37
+ A0N=read_MemoryData[13]
XU72 OAI2BB2XL $PINS Y=n87 B1=FE_OFN141_n35 B0=n16 A1N=FE_OFN139_n37
+ A0N=read_MemoryData[14]
XU73 OAI2BB2XL $PINS Y=n88 B1=FE_OFN141_n35 B0=n17 A1N=FE_OFN139_n37
+ A0N=read_MemoryData[15]
XU74 OAI2BB2XL $PINS Y=n89 B1=FE_OFN136_n36 B0=n18 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[16]
XU75 OAI2BB2XL $PINS Y=n90 B1=FE_OFN139_n37 B0=n19 A1N=FE_OFN139_n37
+ A0N=read_MemoryData[17]
XU76 OAI2BB2XL $PINS Y=n91 B1=FE_OFN140_n35 B0=n20 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[18]
XU77 OAI2BB2XL $PINS Y=n92 B1=FE_OFN141_n35 B0=n21 A1N=FE_OFN139_n37
+ A0N=read_MemoryData[19]
XU78 OAI2BB2XL $PINS Y=n93 B1=FE_OFN141_n35 B0=n22 A1N=FE_OFN137_n36
+ A0N=read_MemoryData[20]
XU79 OAI2BB2XL $PINS Y=n94 B1=FE_OFN138_n37 B0=n23 A1N=FE_OFN138_n37
+ A0N=read_MemoryData[21]
XU80 OAI2BB2XL $PINS Y=n95 B1=FE_OFN136_n36 B0=n24 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[22]
XU81 OAI2BB2XL $PINS Y=n96 B1=FE_OFN136_n36 B0=n25 A1N=FE_OFN136_n36
+ A0N=read_MemoryData[23]
XU82 OAI2BB2XL $PINS Y=n97 B1=n37 B0=n26 A1N=n36 A0N=read_MemoryData[24]
XU83 OAI2BB2XL $PINS Y=n98 B1=n35 B0=n27 A1N=n37 A0N=read_MemoryData[25]
XU84 OAI2BB2XL $PINS Y=n99 B1=FE_OFN140_n35 B0=n28 A1N=n36
+ A0N=read_MemoryData[26]
XU85 OAI2BB2XL $PINS Y=n100 B1=FE_OFN140_n35 B0=n29 A1N=n36
+ A0N=read_MemoryData[27]
XU86 OAI2BB2XL $PINS Y=n101 B1=n35 B0=n30 A1N=n36 A0N=read_MemoryData[28]
XU87 OAI2BB2XL $PINS Y=n102 B1=n35 B0=n31 A1N=n37 A0N=read_MemoryData[29]
XU88 OAI2BB2XL $PINS Y=n103 B1=n37 B0=n32 A1N=n36 A0N=read_MemoryData[30]
XU89 OAI2BB2XL $PINS Y=n104 B1=n37 B0=n33 A1N=n36 A0N=read_MemoryData[31]
XU90 CLKMX2X2 $PINS Y=n105 S0=n144 B=WB[0] A=EX_WB[0]
XMemoryData_reg[31] SDFFRXL $PINS SI=SPCASCAN_N37 SE=test_se RN=FE_OFN169_n149
+ QN=n33 Q=MemoryData[31] D=n104 CK=clk
XMemoryData_reg[30] SDFFRXL $PINS SI=n33 SE=test_se RN=FE_OFN169_n149 QN=n32
+ Q=MemoryData[30] D=n103 CK=clk
XMemoryData_reg[29] SDFFRXL $PINS SI=n32 SE=test_se RN=FE_OFN169_n149 QN=n31
+ Q=MemoryData[29] D=n102 CK=clk
XMemoryData_reg[28] SDFFRXL $PINS SI=n31 SE=test_se RN=FE_OFN169_n149 QN=n30
+ Q=MemoryData[28] D=n101 CK=clk
XMemoryData_reg[27] SDFFRXL $PINS SI=n30 SE=test_se RN=FE_OFN169_n149 QN=n29
+ Q=MemoryData[27] D=n100 CK=clk
XMemoryData_reg[26] SDFFRXL $PINS SI=n29 SE=FE_OFN5_test_se_i RN=FE_OFN169_n149
+ QN=n28 Q=MemoryData[26] D=n99 CK=clk
XMemoryData_reg[25] SDFFRXL $PINS SI=n26 SE=FE_OFN5_test_se_i RN=FE_OFN169_n149
+ QN=n27 Q=MemoryData[25] D=n98 CK=clk
XMemoryData_reg[24] SDFFRXL $PINS SI=n12 SE=FE_OFN5_test_se_i RN=FE_OFN169_n149
+ QN=n26 Q=MemoryData[24] D=n97 CK=clk
XMemoryData_reg[23] SDFFRXL $PINS SI=n2 SE=FE_OFN52_test_se_i RN=n148 QN=n25
+ Q=MemoryData[23] D=n96 CK=clk
XMemoryData_reg[22] SDFFRXL $PINS SI=n20 SE=FE_OFN52_test_se_i RN=n148 QN=n24
+ Q=MemoryData[22] D=n95 CK=clk
XMemoryData_reg[21] SDFFRXL $PINS SI=n51 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n23 Q=MemoryData[21] D=n94 CK=clk_i__L3_N19
XMemoryData_reg[20] SDFFRXL $PINS SI=n52 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n22 Q=MemoryData[20] D=n93 CK=clk_i__L3_N19
XMemoryData_reg[19] SDFFRXL $PINS SI=n16 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n21 Q=MemoryData[19] D=n92 CK=clk_i__L3_N19
XMemoryData_reg[18] SDFFRXL $PINS SI=n25 SE=FE_OFN52_test_se_i RN=n148 QN=n20
+ Q=MemoryData[18] D=n91 CK=clk
XMemoryData_reg[17] SDFFRXL $PINS SI=n22 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n19 Q=MemoryData[17] D=n90 CK=clk_i__L3_N19
XMemoryData_reg[16] SDFFRXL $PINS SI=n14 SE=FE_OFN52_test_se_i RN=n148 QN=n18
+ Q=MemoryData[16] D=n89 CK=clk
XMemoryData_reg[15] SDFFRXL $PINS SI=n15 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n17 Q=MemoryData[15] D=n88 CK=clk_i__L3_N19
XMemoryData_reg[14] SDFFRXL $PINS SI=n17 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n16 Q=MemoryData[14] D=n87 CK=clk_i__L3_N19
XMemoryData_reg[13] SDFFRXL $PINS SI=n18 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n15 Q=MemoryData[13] D=n86 CK=clk_i__L3_N19
XMemoryData_reg[12] SDFFRXL $PINS SI=n23 SE=FE_OFN52_test_se_i
+ RN=FE_OFN168_n148 QN=n14 Q=MemoryData[12] D=n85 CK=clk_i__L3_N19
XMemoryData_reg[11] SDFFRXL $PINS SI=n28 SE=FE_OFN5_test_se_i RN=n147 QN=n13
+ Q=MemoryData[11] D=n84 CK=clk
XMemoryData_reg[10] SDFFRXL $PINS SI=n13 SE=FE_OFN5_test_se_i RN=n147 QN=n12
+ Q=MemoryData[10] D=n83 CK=clk
XMemoryData_reg[9] SDFFRXL $PINS SI=n6 SE=FE_OFN5_test_se_i RN=n147 QN=n11
+ Q=MemoryData[9] D=n82 CK=clk
XMemoryData_reg[8] SDFFRXL $PINS SI=n11 SE=FE_OFN5_test_se_i RN=n147 QN=n10
+ Q=MemoryData[8] D=n81 CK=clk
XMemoryData_reg[7] SDFFRXL $PINS SI=n7 SE=FE_OFN5_test_se_i RN=n147 QN=n9
+ Q=MemoryData[7] D=n80 CK=clk
XMemoryData_reg[6] SDFFRXL $PINS SI=n27 SE=FE_OFN5_test_se_i RN=n147 QN=n8
+ Q=MemoryData[6] D=n79 CK=clk
XMemoryData_reg[5] SDFFRXL $PINS SI=n8 SE=FE_OFN5_test_se_i RN=n147 QN=n7
+ Q=MemoryData[5] D=n78 CK=clk
XMemoryData_reg[4] SDFFRXL $PINS SI=n9 SE=FE_OFN5_test_se_i RN=n147 QN=n6
+ Q=MemoryData[4] D=n77 CK=clk
XMemoryData_reg[3] SDFFRXL $PINS SI=n10 SE=FE_OFN5_test_se_i RN=n147 QN=n5
+ Q=MemoryData[3] D=n76 CK=clk
XMemoryData_reg[2] SDFFRXL $PINS SI=n5 SE=FE_OFN5_test_se_i RN=n147 QN=n4
+ Q=MemoryData[2] D=n75 CK=clk
XMemoryData_reg[1] SDFFRXL $PINS SI=n4 SE=FE_OFN5_test_se_i RN=n147 QN=n3
+ Q=MemoryData[1] D=n74 CK=clk
XMemoryData_reg[0] SDFFRXL $PINS SI=n3 SE=FE_OFN5_test_se_i RN=n147 QN=n2
+ Q=MemoryData[0] D=n73 CK=clk
XALUresult_reg[31] SDFFRXL $PINS SI=SPCASCAN_N35 SE=FE_OFN51_test_se_i RN=n148
+ QN=SPCASCAN_N34 Q=ALUresult[31] D=n143 CK=clk
XALUresult_reg[30] SDFFRXL $PINS SI=n70 SE=FE_OFN51_test_se_i RN=n148 QN=n71
+ Q=ALUresult[30] D=n142 CK=clk
XALUresult_reg[29] SDFFRXL $PINS SI=n68 SE=FE_OFN4_test_se_i RN=n148 QN=n70
+ Q=ALUresult[29] D=n141 CK=clk
XALUresult_reg[28] SDFFRXL $PINS SI=n71 SE=FE_OFN52_test_se_i RN=n148 QN=n69
+ Q=ALUresult[28] D=n140 CK=clk
XALUresult_reg[27] SDFFRXL $PINS SI=n54 SE=FE_OFN52_test_se_i RN=n148 QN=n68
+ Q=ALUresult[27] D=n139 CK=clk_i__L3_N19
XALUresult_reg[26] SDFFRXL $PINS SI=SPCASCAN_N33 SE=FE_OFN4_test_se_i RN=n148
+ QN=n67 Q=ALUresult[26] D=n138 CK=clk_i__L3_N19
XALUresult_reg[25] SDFFRXL $PINS SI=n62 SE=FE_OFN53_test_se_i RN=n148 QN=n66
+ Q=ALUresult[25] D=n137 CK=clk_i__L3_N19
XALUresult_reg[24] SDFFRXL $PINS SI=n53 SE=FE_OFN4_test_se_i RN=n148
+ QN=SPCBSCAN_N42 Q=ALUresult[24] D=n136 CK=clk_i__L3_N19
XALUresult_reg[23] SDFFRXL $PINS SI=SPCBSCAN_N41 SE=FE_OFN53_test_se_i RN=n148
+ QN=SPCASCAN_N32 Q=ALUresult[23] D=n135 CK=clk_i__L3_N19
XALUresult_reg[22] SDFFRXL $PINS SI=SPCASCAN_N31 SE=FE_OFN53_test_se_i RN=n148
+ QN=SPCASCAN_N30 Q=ALUresult[22] D=n134 CK=clk_i__L3_N19
XALUresult_reg[21] SDFFRXL $PINS SI=n61 SE=FE_OFN53_test_se_i RN=n148 QN=n62
+ Q=ALUresult[21] D=n133 CK=clk_i__L3_N19
XALUresult_reg[20] SDFFRXL $PINS SI=n56 SE=FE_OFN53_test_se_i RN=FE_OFN168_n148
+ QN=n61 Q=ALUresult[20] D=n132 CK=clk_i__L3_N19
XALUresult_reg[19] SDFFRXL $PINS SI=n21 SE=FE_OFN53_test_se_i RN=FE_OFN168_n148
+ QN=n60 Q=ALUresult[19] D=n131 CK=clk_i__L3_N19
XALUresult_reg[18] SDFFRXL $PINS SI=n58 SE=FE_OFN53_test_se_i RN=FE_OFN168_n148
+ QN=n59 Q=ALUresult[18] D=n130 CK=clk_i__L3_N19
XALUresult_reg[17] SDFFRXL $PINS SI=n55 SE=FE_OFN53_test_se_i RN=FE_OFN168_n148
+ QN=n58 Q=ALUresult[17] D=n129 CK=clk_i__L3_N19
XALUresult_reg[16] SDFFRXL $PINS SI=n59 SE=FE_OFN54_test_se_i RN=FE_OFN168_n148
+ QN=n57 Q=ALUresult[16] D=n128 CK=clk_i__L3_N19
XALUresult_reg[15] SDFFRXL $PINS SI=n57 SE=FE_OFN53_test_se_i RN=FE_OFN168_n148
+ QN=n56 Q=ALUresult[15] D=n127 CK=clk_i__L3_N19
XALUresult_reg[14] SDFFRXL $PINS SI=n60 SE=FE_OFN53_test_se_i RN=FE_OFN168_n148
+ QN=n55 Q=ALUresult[14] D=n126 CK=clk_i__L3_N19
XALUresult_reg[13] SDFFRXL $PINS SI=n66 SE=FE_OFN52_test_se_i RN=FE_OFN168_n148
+ QN=n54 Q=ALUresult[13] D=n125 CK=clk_i__L3_N19
XALUresult_reg[12] SDFFRXL $PINS SI=n19 SE=FE_OFN52_test_se_i RN=FE_OFN168_n148
+ QN=n53 Q=ALUresult[12] D=n124 CK=clk_i__L3_N19
XALUresult_reg[11] SDFFRXL $PINS SI=n67 SE=FE_OFN52_test_se_i RN=FE_OFN168_n148
+ QN=n52 Q=ALUresult[11] D=n123 CK=clk_i__L3_N19
XALUresult_reg[10] SDFFRXL $PINS SI=n50 SE=FE_OFN52_test_se_i RN=FE_OFN168_n148
+ QN=n51 Q=ALUresult[10] D=n122 CK=clk
XALUresult_reg[9] SDFFRXL $PINS SI=n49 SE=FE_OFN52_test_se_i RN=FE_OFN168_n148
+ QN=n50 Q=ALUresult[9] D=n121 CK=clk
XALUresult_reg[8] SDFFRXL $PINS SI=n24 SE=FE_OFN52_test_se_i RN=n150 QN=n49
+ Q=ALUresult[8] D=n120 CK=clk
XALUresult_reg[7] SDFFRXL $PINS SI=n47 SE=FE_OFN51_test_se_i RN=n150
+ QN=SPCASCAN_N36 Q=ALUresult[7] D=n119 CK=clk
XALUresult_reg[6] SDFFRXL $PINS SI=n69 SE=FE_OFN5_test_se_i RN=n150 QN=n47
+ Q=ALUresult[6] D=n118 CK=clk
XALUresult_reg[5] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_25_
+ SE=FE_OFN5_test_se_i RN=n150 QN=n46 Q=ALUresult[5] D=n117 CK=clk
XALUresult_reg[4] SDFFRXL $PINS SI=n44 SE=FE_OFN5_test_se_i RN=n150 QN=n45
+ Q=ALUresult[4] D=n116 CK=clk
XALUresult_reg[3] SDFFRXL $PINS SI=n46 SE=FE_OFN5_test_se_i RN=n150 QN=n44
+ Q=ALUresult[3] D=n115 CK=clk
XALUresult_reg[2] SDFFRXL $PINS SI=n42 SE=FE_OFN51_test_se_i RN=n150
+ QN=FE_OFN25_SPCASCAN_N6 Q=ALUresult[2] D=n114 CK=clk
XALUresult_reg[1] SDFFRXL $PINS SI=n41 SE=FE_OFN51_test_se_i RN=n150 QN=n42
+ Q=ALUresult[1] D=n113 CK=clk
XALUresult_reg[0] SDFFRXL $PINS SI=n45 SE=FE_OFN51_test_se_i RN=n150 QN=n41
+ Q=ALUresult[0] D=n112 CK=clk
XWB_reg[1] SDFFRXL $PINS SI=n161 SE=FE_OFN14_test_se_i RN=FE_OFN169_n149
+ QN=test_so Q=n169 D=n106 CK=clk_i__L3_N9
XRegisterRd_reg[1] SDFFRXL $PINS SI=n156 SE=FE_OFN14_test_se_i
+ RN=FE_OFN169_n149 QN=n161 Q=n173 D=n108 CK=clk_i__L3_N9
XRegisterRd_reg[2] SDFFRXL $PINS SI=n159 SE=FE_OFN14_test_se_i RN=n150
+ QN=SPCASCAN_N10 Q=n172 D=n109 CK=clk_i__L3_N9
XRegisterRd_reg[3] SDFFRXL $PINS SI=n157 SE=FE_OFN14_test_se_i RN=n150 QN=n159
+ Q=n171 D=n110 CK=clk_i__L3_N9
XWB_reg[0] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_23_ SE=FE_OFN18_test_se_i
+ RN=rst QN=n158 Q=FE_OFN24_MEM_WB_WBControl_0_ D=n105 CK=clk_i__L3_N27
XRegisterRd_reg[4] SDFFRXL $PINS SI=test_so SE=FE_OFN14_test_se_i RN=n150
+ QN=n157 Q=n170 D=n111 CK=clk_i__L3_N9
XRegisterRd_reg[0] SDFFRXL $PINS SI=n158 SE=FE_OFN8_test_se_i RN=FE_OFN169_n149
+ QN=n156 Q=n174 D=n107 CK=clk_i__L3_N9
XU1 CLKBUFX2 $PINS Y=RegisterRd[4] A=n170
XU91 CLKBUFX2 $PINS Y=WB[1] A=n169
XU92 CLKBUFX2 $PINS Y=RegisterRd[2] A=n172
XU93 CLKBUFX2 $PINS Y=RegisterRd[3] A=n171
XU94 CLKBUFX2 $PINS Y=RegisterRd[0] A=n174
XU95 CLKBUFX2 $PINS Y=RegisterRd[1] A=n173
.ENDS

.SUBCKT Execution_DW_cmp_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29]
+ B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16]
+ B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2]
+ B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE n676 n820 n908 n807 n964 n832
+ n780 n737 n895 n977 n794 n767 n235 n846 n236 n620 n606 n623 n943 n624 n621
+ n725 n724 n727 n998 n1018 n728 n237 n954 n582
XU657 OAI21XL $PINS Y=n1317 B0=n1334 A1=n1333 A0=n1332
XU658 AOI32XL $PINS Y=n1372 B1=B[3] B0=n895 A2=n1374 A1=n908 A0=B[2]
XU659 OAI211X1 $PINS Y=n1353 C0=n1358 B0=n1360 A1=n780 A0=B[12]
XU661 NAND2BXL $PINS Y=n1360 B=A[13] AN=B[13]
XU662 AOI32XL $PINS Y=n1359 B1=B[13] B0=n767 A2=n1360 A1=n780 A0=B[12]
XU663 CLKINVX1 $PINS Y=n1312 A=B[1]
XU664 AOI21XL $PINS Y=n1342 B0=n1344 A1=A[26] A0=n727
XU665 OAI211X1 $PINS Y=n1350 C0=n1352 B0=n1351 A1=n832 A0=B[8]
XU666 AOI32XL $PINS Y=n1363 B1=B[9] B0=n820 A2=n1351 A1=n832 A0=B[8]
XU667 AND2XL $PINS Y=n1361 B=n954 A=A[15]
XU668 OAI22XL $PINS Y=n1333 B1=n1340 B0=n1342 A1=n1341 A0=n1340
XU669 OAI22XL $PINS Y=n1334 B1=n1335 B0=n1336 A1=n1280 A0=n1335
XU670 OAI32XL $PINS Y=n1321 B1=n621 B0=A[23] A2=n1325 A1=A[22] A0=n620
XU671 OAI32XL $PINS Y=n1365 B1=n846 B0=A[7] A2=n1369 A1=A[6] A0=n237
XU672 OAI32XL $PINS Y=n1326 B1=n582 B0=A[19] A2=n1330 A1=A[18] A0=n606
XU673 AOI211XL $PINS Y=n1331 C0=n1323 B0=n1324 A1=A[20] A0=n623
XU675 AOI21XL $PINS Y=n1367 B0=n1369 A1=A[6] A0=n237
XU676 AOI21XL $PINS Y=n1327 B0=n1330 A1=A[18] A0=n606
XU677 OAI32XL $PINS Y=n1322 B1=n624 B0=A[21] A2=n1324 A1=A[20] A0=n623
XU678 OAI32XL $PINS Y=n1341 B1=n725 B0=A[25] A2=n1343 A1=A[24] A0=n724
XU679 OAI211XL $PINS Y=n1314 C0=n1346 B0=n1329 A1=n737 A0=B[16]
XU680 NAND3XL $PINS Y=n1347 C=n1371 B=n1370 A=n1367
XU681 NAND2BXL $PINS Y=n1364 B=A[11] AN=B[11]
XU683 AND2XL $PINS Y=n1343 B=n725 A=A[25]
XU684 AND2XL $PINS Y=n1324 B=n624 A=A[21]
XU685 AND2XL $PINS Y=n1344 B=n728 A=A[27]
XU686 AND2XL $PINS Y=n1330 B=n582 A=A[19]
XU687 AND2X2 $PINS Y=n1339 B=n1018 A=A[31]
XU688 AND2XL $PINS Y=n1369 B=n846 A=A[7]
XU689 AO21XL $PINS Y=n1323 B0=n1325 A1=A[22] A0=n620
XU690 AND2XL $PINS Y=n1325 B=n621 A=A[23]
XU699 NOR2BXL $PINS Y=n1368 B=B[5] AN=A[5]
XU700 NAND2BXL $PINS Y=n1329 B=A[17] AN=B[17]
XU701 NAND2BXL $PINS Y=n1351 B=A[9] AN=B[9]
XU702 NAND2BXL $PINS Y=n1374 B=A[3] AN=B[3]
XU707 OAI2BB1X1 $PINS Y=n1318 B0=n1320 A1N=n1277 A0N=n1331
XU708 OA22X1 $PINS Y=n1277 B1=n1326 B0=n1327 A1=n1294 A0=n1326
XU709 CLKINVX1 $PINS Y=n1287 A=n1323
XU710 INVXL $PINS Y=n1298 A=B[14]
XU712 CLKINVX1 $PINS Y=n1299 A=n1359
XU723 CLKINVX1 $PINS Y=n1294 A=n1328
XU725 CLKINVX1 $PINS Y=n1280 A=n1337
XU726 OAI21XL $PINS Y=GE_LT_GT_LE B0=n1316 A1=n1315 A0=n1314
XU727 OAI22XL $PINS Y=n1316 B1=n1317 B0=n1319 A1=n1318 A0=n1317
XU728 OAI22XL $PINS Y=n1320 B1=n1321 B0=n1287 A1=n1322 A0=n1321
XU729 AOI32X1 $PINS Y=n1328 B1=B[17] B0=n676 A2=n1329 A1=n737 A0=B[16]
XU730 AOI32X1 $PINS Y=n1337 B1=B[29] B0=n977 A2=n1338 A1=n964 A0=B[28]
XU731 OAI32X1 $PINS Y=n1335 B1=n1018 B0=A[31] A2=n1339 A1=A[30] A0=n998
XU732 OAI32X1 $PINS Y=n1340 B1=n728 B0=A[27] A2=n1344 A1=A[26] A0=n727
XU733 NAND3X1 $PINS Y=n1315 C=n1327 B=n1331 A=n1319
XU734 AOI211X1 $PINS Y=n1319 C0=n1345 B0=n1343 A1=A[24] A0=n724
XU735 NAND2BX1 $PINS Y=n1345 B=n1342 AN=n1332
XU736 OAI211X1 $PINS Y=n1332 C0=n1336 B0=n1338 A1=n964 A0=B[28]
XU737 AOI21X1 $PINS Y=n1336 B0=n1339 A1=A[30] A0=n998
XU738 NAND2BX1 $PINS Y=n1338 B=A[29] AN=B[29]
XU739 AOI32X1 $PINS Y=n1346 B1=n1350 B0=n1349 A2=n1349 A1=n1348 A0=n1347
XU740 NOR2X1 $PINS Y=n1352 B=n1354 A=n1353
XU741 OA21XL $PINS Y=n1349 B0=n1356 A1=n1355 A0=n1353
XU742 OAI22XL $PINS Y=n1356 B1=n1357 B0=n1358 A1=n1299 A0=n1357
XU743 OAI32X1 $PINS Y=n1357 B1=n954 B0=A[15] A2=n1361 A1=A[14] A0=n1298
XU744 AO22X1 $PINS Y=n1355 B1=n1362 B0=n1354 A1=n1363 A0=n1362
XU745 OAI21XL $PINS Y=n1354 B0=n1364 A1=n807 A0=B[10]
XU746 AOI32X1 $PINS Y=n1362 B1=B[11] B0=n794 A2=n1364 A1=n807 A0=B[10]
XU747 AOI21X1 $PINS Y=n1358 B0=n1361 A1=A[14] A0=n1298
XU748 OAI22XL $PINS Y=n1348 B1=n1365 B0=n1367 A1=n1366 A0=n1365
XU749 OAI32X1 $PINS Y=n1366 B1=n236 B0=A[5] A2=n1368 A1=A[4] A0=n235
XU750 AOI221XL $PINS Y=n1371 C0=n1368 B1=n235 B0=A[4] A1=n1373 A0=n1372
XU751 OAI21XL $PINS Y=n1373 B0=n1374 A1=n908 A0=B[2]
XU752 OAI211X1 $PINS Y=n1370 C0=n1372 B0=n1375 A1=n1312 A0=A[1]
XU753 AO22X1 $PINS Y=n1375 B1=A[1] B0=n1312 A1=A[0] A0=n943
.ENDS

.SUBCKT Execution_DW_rightsh_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] DATA_TC SH[4] SH[3]
+ SH[2] SH[1] SH[0] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22]
+ B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9]
+ B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] n921 n234
XFE_OFC211_n236 CLKBUFX2 $PINS Y=FE_OFN211_n236 A=n236
XFE_OFC208_n233 CLKBUFX2 $PINS Y=FE_OFN208_n233 A=n233
XFE_OFC207_n225 CLKBUFX2 $PINS Y=FE_OFN207_n225 A=n225
XU179 NOR2BX1 $PINS Y=n310 B=n230 AN=n323
XU180 MXI3X1 $PINS Y=B[3] S1=n236 S0=n233 C=n285 B=n248 A=n284
XU181 MXI3X1 $PINS Y=B[14] S1=FE_OFN211_n236 S0=FE_OFN208_n233 C=n292 B=n309
+ A=n273
XU182 MXI3X1 $PINS Y=B[12] S1=FE_OFN211_n236 S0=FE_OFN208_n233 C=n301 B=n313
+ A=n283
XU183 MXI3X1 $PINS Y=B[9] S1=n236 S0=n233 C=n260 B=n259 A=n258
XU184 MXI2XL $PINS Y=n307 S0=n231 B=n330 A=n329
XU185 MX2XL $PINS Y=n347 S0=n225 B=A[14] A=A[13]
XU186 NAND2XL $PINS Y=n263 B=n235 A=n305
XU187 INVXL $PINS Y=n249 A=n332
XU188 CLKMX2X2 $PINS Y=n304 S0=n231 B=n324 A=n323
XU189 NOR2X1 $PINS Y=B[21] B=n275 A=FE_OFN211_n236
XU190 MXI3XL $PINS Y=B[15] S1=FE_OFN211_n236 S0=n233 C=n291 B=n307 A=n268
XU191 MXI3XL $PINS Y=B[13] S1=n236 S0=n233 C=n300 B=n311 A=n278
XU192 CLKINVX1 $PINS Y=n253 A=n271
XU193 NAND2XL $PINS Y=n302 B=n235 A=n320
XU194 NAND2XL $PINS Y=n303 B=n235 A=n322
XU195 NAND2XL $PINS Y=n291 B=n235 A=n306
XU196 NOR2XL $PINS Y=B[22] B=n270 A=FE_OFN211_n236
XU197 INVX1 $PINS Y=n248 A=n286
XU198 MXI2XL $PINS Y=n288 S0=SH[0] B=A[6] A=A[5]
XU199 MXI2XL $PINS Y=n287 S0=SH[0] B=A[4] A=A[3]
XU200 NOR2BXL $PINS Y=n338 B=FE_OFN207_n225 AN=A[31]
XU201 MX2XL $PINS Y=n365 S0=n225 B=A[1] A=A[0]
XU202 MX2XL $PINS Y=n346 S0=n225 B=A[16] A=A[15]
XU203 MX2XL $PINS Y=n353 S0=FE_OFN207_n225 B=A[29] A=A[28]
XU204 MX2XL $PINS Y=n354 S0=FE_OFN207_n225 B=A[27] A=A[26]
XU205 MX2XL $PINS Y=n358 S0=FE_OFN207_n225 B=A[25] A=A[24]
XU206 MX2XL $PINS Y=n343 S0=FE_OFN207_n225 B=A[26] A=A[25]
XU207 MX2XL $PINS Y=n359 S0=FE_OFN207_n225 B=A[23] A=A[22]
XU208 MX2XL $PINS Y=n340 S0=FE_OFN207_n225 B=A[24] A=A[23]
XU209 MX2XL $PINS Y=n341 S0=FE_OFN207_n225 B=A[22] A=A[21]
XU210 MX2XL $PINS Y=n357 S0=FE_OFN207_n225 B=A[19] A=A[18]
XU211 MX2XL $PINS Y=n356 S0=FE_OFN207_n225 B=A[21] A=A[20]
XU212 MX2XL $PINS Y=n344 S0=FE_OFN207_n225 B=A[20] A=A[19]
XU213 MX2XL $PINS Y=n289 S0=n225 B=A[8] A=A[7]
XU214 MX2XL $PINS Y=n318 S0=n225 B=A[12] A=A[11]
XU215 MX2XL $PINS Y=n290 S0=n225 B=A[10] A=A[9]
XU216 MX2XL $PINS Y=n299 S0=n225 B=A[9] A=A[8]
XU217 MX2XL $PINS Y=n361 S0=n225 B=A[13] A=A[12]
XU218 MX2XL $PINS Y=n360 S0=n225 B=A[11] A=A[10]
XU219 MX2XL $PINS Y=n362 S0=FE_OFN207_n225 B=A[17] A=A[16]
XU220 MX2XL $PINS Y=n363 S0=n225 B=A[15] A=A[14]
XU221 MX2XL $PINS Y=n342 S0=FE_OFN207_n225 B=A[28] A=A[27]
XU222 MX2XL $PINS Y=n298 S0=n225 B=A[7] A=A[6]
XU223 MX2XL $PINS Y=n339 S0=FE_OFN207_n225 B=A[30] A=A[29]
XU224 MX2XL $PINS Y=n345 S0=n225 B=A[18] A=A[17]
XU225 MX2XL $PINS Y=n297 S0=n225 B=A[5] A=A[4]
XU226 MX2XL $PINS Y=n355 S0=FE_OFN207_n225 B=A[31] A=A[30]
XU227 MX2XL $PINS Y=n296 S0=n225 B=A[3] A=A[2]
XU228 CLKINVX1 $PINS Y=n239 A=n327
XU229 CLKINVX1 $PINS Y=n243 A=n307
XU230 CLKINVX1 $PINS Y=n244 A=n309
XU231 CLKINVX1 $PINS Y=n245 A=n311
XU232 CLKINVX1 $PINS Y=n247 A=n259
XU233 CLKINVX1 $PINS Y=n246 A=n313
XU234 CLKINVX1 $PINS Y=n238 A=n302
XU235 CLKINVX1 $PINS Y=n241 A=n303
XU236 CLKINVX1 $PINS Y=n240 A=n263
XU237 INVX3 $PINS Y=n228 A=n227
XU239 INVX2 $PINS Y=n231 A=n230
XU241 CLKINVX1 $PINS Y=n233 A=n235
XU242 CLKINVX1 $PINS Y=n250 A=n337
XU243 CLKINVX1 $PINS Y=n251 A=n352
XU244 CLKINVX1 $PINS Y=n252 A=n277
XU245 CLKBUFX3 $PINS Y=n225 A=SH[0]
XU248 CLKBUFX3 $PINS Y=n236 A=SH[4]
XU250 CLKINVX1 $PINS Y=n255 A=n288
XU251 CLKINVX1 $PINS Y=n242 A=n295
XU252 CLKBUFX3 $PINS Y=n227 A=SH[1]
XU253 CLKBUFX3 $PINS Y=n230 A=SH[2]
XU254 CLKINVX1 $PINS Y=n235 A=SH[3]
XU256 CLKINVX1 $PINS Y=n254 A=n281
XU258 MX3XL $PINS Y=B[8] S1=FE_OFN211_n236 S0=FE_OFN208_n233 C=n240 B=n262
+ A=n261
XU259 MXI2X1 $PINS Y=B[7] S0=FE_OFN211_n236 B=n265 A=n264
XU260 MX3XL $PINS Y=n264 S1=FE_OFN208_n233 S0=n230 C=n268 B=n267 A=n266
XU261 MXI2X1 $PINS Y=B[6] S0=n236 B=n270 A=n269
XU262 MX3XL $PINS Y=n269 S1=FE_OFN208_n233 S0=n230 C=n273 B=n272 A=n271
XU263 MXI2X1 $PINS Y=B[5] S0=n236 B=n275 A=n274
XU264 MX3XL $PINS Y=n274 S1=n233 S0=n230 C=n278 B=n277 A=n276
XU265 MXI2X1 $PINS Y=B[4] S0=FE_OFN211_n236 B=n280 A=n279
XU266 MX3XL $PINS Y=n279 S1=FE_OFN208_n233 S0=n230 C=n283 B=n282 A=n281
XU267 MX3XL $PINS Y=n284 S1=n230 S0=n227 C=n266 B=n288 A=n287
XU268 MXI2X1 $PINS Y=n266 S0=n227 B=n290 A=n289
XU269 NOR2X1 $PINS Y=B[31] B=n291 A=SH[4]
XU270 NOR2X1 $PINS Y=B[30] B=n292 A=SH[4]
XU271 MX3XL $PINS Y=B[2] S1=n236 S0=FE_OFN208_n233 C=n242 B=n294 A=n293
XU272 MX3XL $PINS Y=n293 S1=n230 S0=n227 C=n253 B=n297 A=n296
XU273 MXI2X1 $PINS Y=n271 S0=n227 B=n299 A=n298
XU274 NOR2X1 $PINS Y=B[29] B=n300 A=SH[4]
XU275 NOR2X1 $PINS Y=B[28] B=n301 A=FE_OFN211_n236
XU276 NOR2X1 $PINS Y=B[27] B=n302 A=FE_OFN211_n236
XU277 NOR2X1 $PINS Y=B[26] B=n303 A=FE_OFN211_n236
XU278 NOR2X1 $PINS Y=B[25] B=n260 A=FE_OFN211_n236
XU279 NAND2X1 $PINS Y=n260 B=n235 A=n304
XU280 NOR2X1 $PINS Y=B[24] B=n263 A=FE_OFN211_n236
XU281 NOR2X1 $PINS Y=B[23] B=n265 A=FE_OFN211_n236
XU282 MXI2X1 $PINS Y=n265 S0=n233 B=n306 A=n243
XU283 MXI2X1 $PINS Y=n270 S0=FE_OFN208_n233 B=n308 A=n244
XU284 MXI2X1 $PINS Y=n275 S0=n233 B=n310 A=n245
XU285 NOR2X1 $PINS Y=B[20] B=n280 A=FE_OFN211_n236
XU286 MXI2X1 $PINS Y=n280 S0=FE_OFN208_n233 B=n312 A=n246
XU287 MXI2X1 $PINS Y=B[1] S0=n236 B=n315 A=n314
XU288 MX3XL $PINS Y=n314 S1=n233 S0=n230 C=n258 B=n276 A=n316
XU289 MXI2X1 $PINS Y=n258 S0=n230 B=n317 A=n252
XU290 MXI2X1 $PINS Y=n277 S0=n227 B=n318 A=n290
XU291 MXI2X1 $PINS Y=n276 S0=n227 B=n289 A=n255
XU292 MX3XL $PINS Y=n316 S1=n227 S0=SH[0] C=n287 B=n234 A=n921
XU293 NOR2X1 $PINS Y=B[19] B=n285 A=FE_OFN211_n236
XU294 MXI2X1 $PINS Y=n285 S0=FE_OFN208_n233 B=n320 A=n319
XU295 NOR2X1 $PINS Y=B[18] B=n295 A=FE_OFN211_n236
XU296 MXI2X1 $PINS Y=n295 S0=FE_OFN208_n233 B=n322 A=n321
XU297 NOR2X1 $PINS Y=B[17] B=n315 A=SH[4]
XU298 MXI2X1 $PINS Y=n315 S0=n233 B=n304 A=n247
XU299 MXI2X1 $PINS Y=n259 S0=n231 B=n326 A=n325
XU300 NOR2X1 $PINS Y=B[16] B=n327 A=FE_OFN211_n236
XU301 NOR2BX1 $PINS Y=n306 B=n230 AN=n328
XU302 MXI2X1 $PINS Y=n268 S0=n230 B=n331 A=n249
XU303 NAND2X1 $PINS Y=n292 B=n235 A=n308
XU304 NOR2BX1 $PINS Y=n308 B=n230 AN=n333
XU305 MXI2X1 $PINS Y=n309 S0=n231 B=n335 A=n334
XU306 MXI2X1 $PINS Y=n273 S0=n230 B=n336 A=n250
XU307 NAND2X1 $PINS Y=n300 B=n235 A=n310
XU308 CLKMX2X2 $PINS Y=n323 S0=n228 B=n339 A=n338
XU309 MXI2X1 $PINS Y=n311 S0=n231 B=n325 A=n324
XU310 CLKMX2X2 $PINS Y=n325 S0=n228 B=n341 A=n340
XU311 CLKMX2X2 $PINS Y=n324 S0=n228 B=n343 A=n342
XU312 MXI2X1 $PINS Y=n278 S0=n230 B=n326 A=n317
XU313 CLKMX2X2 $PINS Y=n326 S0=n228 B=n345 A=n344
XU314 CLKMX2X2 $PINS Y=n317 S0=n228 B=n347 A=n346
XU315 NAND2X1 $PINS Y=n301 B=n235 A=n312
XU316 NOR2BX1 $PINS Y=n312 B=n230 AN=n348
XU317 MXI2X1 $PINS Y=n313 S0=n231 B=n350 A=n349
XU318 MXI2X1 $PINS Y=n283 S0=n230 B=n351 A=n251
XU319 MX3XL $PINS Y=B[11] S1=FE_OFN211_n236 S0=n233 C=n238 B=n319 A=n286
XU320 CLKMX2X2 $PINS Y=n320 S0=n231 B=n329 A=n328
XU321 CLKMX2X2 $PINS Y=n329 S0=n228 B=n342 A=n339
XU322 NOR2BX1 $PINS Y=n328 B=n227 AN=n338
XU323 CLKMX2X2 $PINS Y=n319 S0=n231 B=n331 A=n330
XU324 CLKMX2X2 $PINS Y=n331 S0=n228 B=n344 A=n341
XU325 CLKMX2X2 $PINS Y=n330 S0=n228 B=n340 A=n343
XU326 MXI2X1 $PINS Y=n286 S0=n231 B=n267 A=n332
XU327 MXI2X1 $PINS Y=n267 S0=n227 B=n347 A=n318
XU328 MXI2X1 $PINS Y=n332 S0=n228 B=n346 A=n345
XU329 MX3XL $PINS Y=B[10] S1=FE_OFN211_n236 S0=FE_OFN208_n233 C=n241 B=n321
+ A=n294
XU330 CLKMX2X2 $PINS Y=n322 S0=n231 B=n334 A=n333
XU331 CLKMX2X2 $PINS Y=n334 S0=n228 B=n354 A=n353
XU332 NOR2BX1 $PINS Y=n333 B=n227 AN=n355
XU333 CLKMX2X2 $PINS Y=n321 S0=n231 B=n336 A=n335
XU334 CLKMX2X2 $PINS Y=n336 S0=n228 B=n357 A=n356
XU335 CLKMX2X2 $PINS Y=n335 S0=n228 B=n359 A=n358
XU336 MXI2X1 $PINS Y=n294 S0=n231 B=n272 A=n337
XU337 MXI2X1 $PINS Y=n272 S0=n227 B=n361 A=n360
XU338 MXI2X1 $PINS Y=n337 S0=n228 B=n363 A=n362
XU339 MX3XL $PINS Y=B[0] S1=n236 S0=FE_OFN208_n233 C=n239 B=n261 A=n364
XU340 MXI2X1 $PINS Y=n327 S0=n233 B=n305 A=n262
XU341 CLKMX2X2 $PINS Y=n305 S0=n231 B=n349 A=n348
XU342 CLKMX2X2 $PINS Y=n349 S0=n228 B=n358 A=n354
XU343 CLKMX2X2 $PINS Y=n348 S0=n228 B=n353 A=n355
XU344 CLKMX2X2 $PINS Y=n262 S0=n231 B=n351 A=n350
XU345 CLKMX2X2 $PINS Y=n351 S0=n228 B=n362 A=n357
XU346 CLKMX2X2 $PINS Y=n350 S0=n228 B=n356 A=n359
XU347 MXI2X1 $PINS Y=n261 S0=n231 B=n282 A=n352
XU348 MXI2X1 $PINS Y=n282 S0=n227 B=n360 A=n299
XU349 MXI2X1 $PINS Y=n352 S0=n228 B=n361 A=n363
XU350 MX3XL $PINS Y=n364 S1=n230 S0=n227 C=n254 B=n296 A=n365
XU351 MXI2X1 $PINS Y=n281 S0=n227 B=n298 A=n297
.ENDS

.SUBCKT Execution_DW_leftsh_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] SH[4] SH[3] SH[2]
+ SH[1] SH[0] B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21]
+ B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8]
+ B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] FE_PT1_n245 FE_PT1_n249
XFE_OFC209_n231 CLKBUFX2 $PINS Y=FE_OFN209_n231 A=n231
XFE_OFC206_n249 CLKBUFX2 $PINS Y=FE_OFN206_n249 A=FE_PT1_n249
XU178 MXI3X1 $PINS Y=B[18] S1=n234 S0=FE_OFN209_n231 C=n272 B=n326 A=n291
XU179 MXI3X1 $PINS Y=B[16] S1=n234 S0=FE_OFN209_n231 C=n335 B=n301 A=n303
XU180 MXI3X1 $PINS Y=B[17] S1=FE_PT1_n245 S0=FE_OFN209_n231 C=n321 B=n295
+ A=n297
XU181 MXI3X1 $PINS Y=B[19] S1=FE_PT1_n245 S0=FE_OFN209_n231 C=n260 B=n322
+ A=n286
XU182 MXI3X1 $PINS Y=B[22] S1=n234 S0=FE_OFN209_n231 C=n257 B=n309 A=n270
XU183 MXI3X1 $PINS Y=n222 S1=SH[1] S0=SH[0] C=n271 B=A[29] A=A[30]
XU184 MX2X1 $PINS Y=n310 S0=n229 B=n345 A=n344
XU185 CLKMX2X2 $PINS Y=n318 S0=n229 B=n336 A=n354
XU186 NOR2BX1 $PINS Y=n300 B=n228 AN=n354
XU187 MX2X1 $PINS Y=n306 S0=n229 B=n341 A=n340
XU188 INVX1 $PINS Y=n244 A=n309
XU189 MX2XL $PINS Y=n339 S0=FE_OFN206_n249 B=A[13] A=A[14]
XU190 NOR2BX1 $PINS Y=n327 B=SH[2] AN=n344
XU191 NOR2BX1 $PINS Y=n323 B=n228 AN=n340
XU192 MX2XL $PINS Y=n350 S0=FE_OFN206_n249 B=A[0] A=A[1]
XU193 MXI2XL $PINS Y=n279 S0=n229 B=n302 A=n319
XU194 MXI2XL $PINS Y=n274 S0=n229 B=n296 A=n315
XU195 MX2X1 $PINS Y=n314 S0=n229 B=n331 A=n330
XU196 NOR2X1 $PINS Y=B[11] B=n284 A=FE_PT1_n245
XU197 NOR2X1 $PINS Y=B[10] B=n289 A=FE_PT1_n245
XU198 NOR2X1 $PINS Y=B[8] B=n255 A=SH[4]
XU199 NOR2BX1 $PINS Y=n294 B=n228 AN=n330
XU200 NOR2XL $PINS Y=B[14] B=n268 A=FE_PT1_n245
XU201 NOR2XL $PINS Y=B[15] B=n263 A=FE_PT1_n245
XU202 NOR2XL $PINS Y=B[12] B=n280 A=FE_PT1_n245
XU203 NOR2XL $PINS Y=B[2] B=n272 A=FE_PT1_n245
XU204 NOR2XL $PINS Y=B[0] B=n335 A=FE_PT1_n245
XU205 NOR2XL $PINS Y=B[13] B=n275 A=FE_PT1_n245
XU206 NOR2XL $PINS Y=B[9] B=n254 A=FE_PT1_n245
XU207 NOR2XL $PINS Y=B[1] B=n321 A=FE_PT1_n245
XU208 NOR2XL $PINS Y=B[3] B=n260 A=FE_PT1_n245
XU209 NOR2XL $PINS Y=B[4] B=n259 A=FE_PT1_n245
XU210 NOR2XL $PINS Y=B[7] B=n256 A=FE_PT1_n245
XU211 NOR2XL $PINS Y=B[6] B=n257 A=FE_PT1_n245
XU212 NOR2XL $PINS Y=B[5] B=n258 A=FE_PT1_n245
XU213 NOR2BXL $PINS Y=n360 B=SH[0] AN=A[0]
XU214 MX2XL $PINS Y=n353 S0=FE_OFN206_n249 B=A[8] A=A[9]
XU215 MX2XL $PINS Y=n343 S0=FE_OFN206_n249 B=A[12] A=A[13]
XU216 MX2XL $PINS Y=n351 S0=FE_OFN206_n249 B=A[10] A=A[11]
XU217 MX2XL $PINS Y=n359 S0=FE_OFN206_n249 B=A[7] A=A[8]
XU218 MX2XL $PINS Y=n357 S0=FE_OFN206_n249 B=A[9] A=A[10]
XU219 MX2XL $PINS Y=n347 S0=FE_OFN206_n249 B=A[11] A=A[12]
XU220 MX2XL $PINS Y=n348 S0=FE_OFN206_n249 B=A[2] A=A[3]
XU221 MX2XL $PINS Y=n356 S0=FE_OFN206_n249 B=A[3] A=A[4]
XU222 MX2XL $PINS Y=n358 S0=FE_OFN206_n249 B=A[5] A=A[6]
XU223 MX2XL $PINS Y=n352 S0=FE_OFN206_n249 B=A[6] A=A[7]
XU224 MX2XL $PINS Y=n355 S0=FE_OFN206_n249 B=A[1] A=A[2]
XU225 MX2XL $PINS Y=n349 S0=FE_OFN206_n249 B=A[4] A=A[5]
XU226 MX2XL $PINS Y=n329 S0=FE_OFN206_n249 B=A[15] A=A[16]
XU227 MX2XL $PINS Y=n334 S0=FE_OFN206_n249 B=A[14] A=A[15]
XU228 MX2XL $PINS Y=n320 S0=FE_OFN206_n249 B=A[17] A=A[18]
XU229 MX2XL $PINS Y=n325 S0=FE_OFN206_n249 B=A[16] A=A[17]
XU230 MX2XL $PINS Y=n316 S0=FE_PT1_n249 B=A[18] A=A[19]
XU231 MX2XL $PINS Y=n304 S0=FE_PT1_n249 B=A[21] A=A[22]
XU232 MX2XL $PINS Y=n312 S0=FE_PT1_n249 B=A[19] A=A[20]
XU233 MX2XL $PINS Y=n287 S0=FE_PT1_n249 B=A[24] A=A[25]
XU234 MX2XL $PINS Y=n298 S0=FE_PT1_n249 B=A[22] A=A[23]
XU235 MX2XL $PINS Y=n308 S0=FE_PT1_n249 B=A[20] A=A[21]
XU236 MX2XL $PINS Y=n292 S0=FE_PT1_n249 B=A[23] A=A[24]
XU237 MX2XL $PINS Y=n276 S0=FE_PT1_n249 B=A[26] A=A[27]
XU238 MX2XL $PINS Y=n281 S0=FE_PT1_n249 B=A[25] A=A[26]
XU239 MX2XL $PINS Y=n271 S0=SH[0] B=A[27] A=A[28]
XU240 MX2XL $PINS Y=n265 S0=FE_PT1_n249 B=A[28] A=A[29]
XU241 MX2XL $PINS Y=n264 S0=FE_PT1_n249 B=A[30] A=A[31]
XU242 CLKINVX1 $PINS Y=n243 A=n263
XU243 CLKINVX1 $PINS Y=n246 A=n280
XU244 CLKINVX1 $PINS Y=n245 A=n275
XU245 CLKINVX1 $PINS Y=n247 A=n322
XU246 CLKINVX1 $PINS Y=n248 A=n326
XU247 CLKINVX1 $PINS Y=n249 A=n295
XU248 CLKINVX1 $PINS Y=n250 A=n301
XU249 INVX3 $PINS Y=n226 A=n225
XU250 INVX3 $PINS Y=n229 A=n228
XU252 CLKINVX1 $PINS Y=n231 A=n233
XU254 CLKINVX1 $PINS Y=n240 A=n307
XU255 CLKINVX1 $PINS Y=n241 A=n315
XU256 CLKINVX1 $PINS Y=n242 A=n319
XU257 CLKINVX1 $PINS Y=n239 A=n290
XU258 CLKINVX1 $PINS Y=n236 A=n266
XU259 CLKINVX1 $PINS Y=n237 A=n277
XU260 CLKINVX1 $PINS Y=n252 A=n258
XU261 CLKINVX1 $PINS Y=n251 A=n256
XU262 CLKINVX1 $PINS Y=n253 A=n259
XU266 CLKBUFX3 $PINS Y=n234 A=SH[4]
XU268 CLKINVX1 $PINS Y=n238 A=n282
XU269 CLKBUFX3 $PINS Y=n228 A=SH[2]
XU270 CLKBUFX3 $PINS Y=n225 A=SH[1]
XU271 CLKINVX1 $PINS Y=n233 A=SH[3]
XU272 MX3X1 $PINS Y=B[31] S1=n234 S0=n231 C=n243 B=n262 A=n261
XU273 MX3XL $PINS Y=n261 S1=n228 S0=n225 C=n236 B=n265 A=n264
XU274 MXI2X1 $PINS Y=B[30] S0=n234 B=n268 A=n267
XU275 MX3XL $PINS Y=n267 S1=FE_OFN209_n231 S0=n228 C=n270 B=n269 A=n222
XU276 MX3XL $PINS Y=B[29] S1=n234 S0=n231 C=n245 B=n274 A=n273
XU277 MX3XL $PINS Y=n273 S1=n228 S0=n225 C=n237 B=n276 A=n265
XU278 MX3XL $PINS Y=B[28] S1=n234 S0=FE_OFN209_n231 C=n246 B=n279 A=n278
XU279 MX3XL $PINS Y=n278 S1=n228 S0=n225 C=n238 B=n281 A=n271
XU280 MXI2X1 $PINS Y=B[27] S0=n234 B=n284 A=n283
XU281 MX3XL $PINS Y=n283 S1=n231 S0=n228 C=n286 B=n285 A=n266
XU282 MXI2X1 $PINS Y=n266 S0=n225 B=n287 A=n276
XU283 MXI2X1 $PINS Y=B[26] S0=n234 B=n289 A=n288
XU284 MX3XL $PINS Y=n288 S1=FE_OFN209_n231 S0=n228 C=n291 B=n290 A=n269
XU285 MXI2X1 $PINS Y=n269 S0=n225 B=n292 A=n281
XU286 MXI2X1 $PINS Y=B[25] S0=n234 B=n254 A=n293
XU287 MXI2X1 $PINS Y=n254 S0=FE_OFN209_n231 B=n294 A=n249
XU288 MX3XL $PINS Y=n293 S1=n231 S0=n228 C=n297 B=n296 A=n277
XU289 MXI2X1 $PINS Y=n277 S0=n225 B=n298 A=n287
XU290 MXI2X1 $PINS Y=B[24] S0=n234 B=n255 A=n299
XU291 MXI2X1 $PINS Y=n255 S0=FE_OFN209_n231 B=n300 A=n250
XU292 MX3XL $PINS Y=n299 S1=FE_OFN209_n231 S0=n228 C=n303 B=n302 A=n282
XU293 MXI2X1 $PINS Y=n282 S0=n225 B=n304 A=n292
XU294 MX3XL $PINS Y=B[23] S1=n234 S0=n231 C=n251 B=n305 A=n262
XU295 NAND2X1 $PINS Y=n256 B=n233 A=n306
XU296 MXI2X1 $PINS Y=n262 S0=n229 B=n285 A=n307
XU297 MXI2X1 $PINS Y=n285 S0=n225 B=n308 A=n298
XU298 NAND2X1 $PINS Y=n257 B=n233 A=n310
XU299 MXI2X1 $PINS Y=n270 S0=n228 B=n311 A=n239
XU300 MXI2X1 $PINS Y=n290 S0=n225 B=n312 A=n304
XU301 MX3XL $PINS Y=B[21] S1=n234 S0=FE_OFN209_n231 C=n252 B=n313 A=n274
XU302 NAND2X1 $PINS Y=n258 B=n233 A=n314
XU303 MXI2X1 $PINS Y=n296 S0=n225 B=n316 A=n308
XU304 MX3XL $PINS Y=B[20] S1=FE_PT1_n245 S0=FE_OFN209_n231 C=n253 B=n317 A=n279
XU305 NAND2X1 $PINS Y=n259 B=n233 A=n318
XU306 MXI2X1 $PINS Y=n302 S0=n225 B=n320 A=n312
XU307 NAND2X1 $PINS Y=n260 B=n233 A=n323
XU308 MXI2X1 $PINS Y=n286 S0=n228 B=n324 A=n240
XU309 MXI2X1 $PINS Y=n307 S0=n226 B=n316 A=n325
XU310 NAND2X1 $PINS Y=n272 B=n233 A=n327
XU311 MXI2X1 $PINS Y=n291 S0=n228 B=n328 A=n311
XU312 CLKMX2X2 $PINS Y=n311 S0=n226 B=n320 A=n329
XU313 NAND2X1 $PINS Y=n321 B=n233 A=n294
XU314 MXI2X1 $PINS Y=n295 S0=n229 B=n332 A=n331
XU315 MXI2X1 $PINS Y=n297 S0=n228 B=n333 A=n241
XU316 MXI2X1 $PINS Y=n315 S0=n226 B=n325 A=n334
XU317 MXI2X1 $PINS Y=n301 S0=n229 B=n337 A=n336
XU318 MXI2X1 $PINS Y=n303 S0=n228 B=n338 A=n242
XU319 MXI2X1 $PINS Y=n319 S0=n226 B=n329 A=n339
XU320 MXI2X1 $PINS Y=n263 S0=FE_OFN209_n231 B=n306 A=n305
XU321 CLKMX2X2 $PINS Y=n305 S0=n229 B=n324 A=n342
XU322 CLKMX2X2 $PINS Y=n324 S0=n226 B=n334 A=n343
XU323 MXI2X1 $PINS Y=n268 S0=FE_OFN209_n231 B=n310 A=n244
XU324 MXI2X1 $PINS Y=n309 S0=n229 B=n328 A=n346
XU325 CLKMX2X2 $PINS Y=n328 S0=n226 B=n339 A=n347
XU326 MXI2X1 $PINS Y=n275 S0=FE_OFN209_n231 B=n314 A=n313
XU327 CLKMX2X2 $PINS Y=n331 S0=n226 B=n349 A=n348
XU328 NOR2BX1 $PINS Y=n330 B=n225 AN=n350
XU329 CLKMX2X2 $PINS Y=n313 S0=n229 B=n333 A=n332
XU330 CLKMX2X2 $PINS Y=n333 S0=n226 B=n343 A=n351
XU331 CLKMX2X2 $PINS Y=n332 S0=n226 B=n353 A=n352
XU332 MXI2X1 $PINS Y=n280 S0=FE_OFN209_n231 B=n318 A=n317
XU333 CLKMX2X2 $PINS Y=n336 S0=n226 B=n356 A=n355
XU334 CLKMX2X2 $PINS Y=n317 S0=n229 B=n338 A=n337
XU335 CLKMX2X2 $PINS Y=n338 S0=n226 B=n347 A=n357
XU336 CLKMX2X2 $PINS Y=n337 S0=n226 B=n359 A=n358
XU337 MXI2X1 $PINS Y=n284 S0=FE_OFN209_n231 B=n323 A=n247
XU338 CLKMX2X2 $PINS Y=n340 S0=n226 B=n348 A=n350
XU339 MXI2X1 $PINS Y=n322 S0=n229 B=n342 A=n341
XU340 CLKMX2X2 $PINS Y=n342 S0=n226 B=n351 A=n353
XU341 CLKMX2X2 $PINS Y=n341 S0=n226 B=n352 A=n349
XU342 MXI2X1 $PINS Y=n289 S0=FE_OFN209_n231 B=n327 A=n248
XU343 CLKMX2X2 $PINS Y=n344 S0=n226 B=n355 A=n360
XU344 MXI2X1 $PINS Y=n326 S0=n229 B=n346 A=n345
XU345 CLKMX2X2 $PINS Y=n346 S0=n226 B=n357 A=n359
XU346 CLKMX2X2 $PINS Y=n345 S0=n226 B=n358 A=n356
XU347 NAND2X1 $PINS Y=n335 B=n233 A=n300
XU348 NOR2BX1 $PINS Y=n354 B=n225 AN=n360
.ENDS

.SUBCKT Execution_DW01_sub_1 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29]
+ B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16]
+ B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2]
+ B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26] DIFF[25]
+ DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18] DIFF[17]
+ DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10] DIFF[9]
+ DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1] DIFF[0] CO
+ FE_PT1_n235 n896 FE_PT1_n236 n954 FE_PT1_n237 n821 n808 n781 n921 FE_PT1_n234
+ n846 n1018 n998 n978 n965 n833 n606 n727 n728 n738 n943 n768 n620 n724 n725
+ n621 n582 n677 n624 n623
XU298 OAI21XL $PINS Y=n65 B0=n67 A1=n70 A0=n66
XU299 OAI21XL $PINS Y=n170 B0=n172 A1=n175 A0=n171
XU302 NOR2X1 $PINS Y=n169 B=n171 A=n174
XU309 OAI21XL $PINS Y=n86 B0=n88 A1=n91 A0=n87
XU310 OAI21XL $PINS Y=n196 B0=n198 A1=n199 A0=n197
XU311 OAI21XL $PINS Y=n178 B0=n180 A1=n185 A0=n179
XU313 OAI21XL $PINS Y=n134 B0=n136 A1=n141 A0=n135
XU314 NOR2X1 $PINS Y=n50 B=n52 A=n57
XU315 NOR2X1 $PINS Y=n160 B=A[9] A=n821
XU316 NOR2X1 $PINS Y=n123 B=A[15] A=n954
XU317 NAND2X1 $PINS Y=n194 B=A[2] A=FE_PT1_n234
XU318 NOR2X1 $PINS Y=n148 B=A[11] A=n251
XU319 NOR2X1 $PINS Y=n133 B=n135 A=n140
XU322 NOR2X1 $PINS Y=n117 B=n119 A=n144
XU323 AOI21X1 $PINS Y=n145 B0=n147 A1=n146 A0=n159
XU324 NOR2X1 $PINS Y=n66 B=A[25] A=n725
XU325 NOR2X1 $PINS Y=n100 B=A[19] A=n582
XU327 NOR2X1 $PINS Y=n87 B=A[21] A=n624
XU328 NAND2XL $PINS Y=n124 B=A[15] A=n954
XU333 INVX1 $PINS Y=n365 A=n142
XU334 NAND2X1 $PINS Y=n130 B=n132 A=n366
XU335 AOI21X1 $PINS Y=n116 B0=n118 A1=n117 A0=n166
XU336 OAI21X1 $PINS Y=n47 B0=n49 A1=n48 A0=n116
XU337 XNOR2X1 $PINS Y=DIFF[14] B=n18 A=n130
XU338 AO21X1 $PINS Y=n368 B0=n127 A1=n217 A0=n130
XU339 XNOR2X1 $PINS Y=DIFF[15] B=n17 A=n368
XU340 NAND2X1 $PINS Y=n154 B=A[10] A=n808
XU341 INVX1 $PINS Y=n142 A=n143
XU342 NAND2X1 $PINS Y=n366 B=n133 A=n365
XU344 INVXL $PINS Y=n132 A=n134
XU345 NAND2XL $PINS Y=n172 B=A[7] A=n846
XU346 AOI21XL $PINS Y=n105 B0=n107 A1=n106 A0=n115
XU347 INVX1 $PINS Y=n157 A=n159
XU348 INVXL $PINS Y=n156 A=n158
XU349 NOR2X1 $PINS Y=n171 B=A[7] A=n846
XU350 AOI21X1 $PINS Y=n93 B0=n95 A1=n94 A0=n115
XU351 NOR2X1 $PINS Y=n158 B=n160 A=n163
XU352 OR2X1 $PINS Y=n367 B=n164 A=n160
XU353 NAND2X1 $PINS Y=n159 B=n161 A=n367
XU354 NAND2X1 $PINS Y=n185 B=A[4] A=FE_PT1_n235
XU355 NOR2X1 $PINS Y=n193 B=A[2] A=FE_PT1_n234
XU356 NAND2XL $PINS Y=n109 B=A[17] A=n677
XU357 NOR2X1 $PINS Y=n79 B=A[23] A=n621
XU358 NOR2X1 $PINS Y=n82 B=A[22] A=n620
XU359 NAND2XL $PINS Y=n149 B=A[11] A=n251
XU360 NAND2XL $PINS Y=n91 B=A[20] A=n623
XU361 NAND2XL $PINS Y=n83 B=A[22] A=n620
XU362 NAND2X1 $PINS Y=n70 B=A[24] A=n724
XU363 NOR2XL $PINS Y=n40 B=A[29] A=n978
XU364 NAND2XL $PINS Y=n164 B=A[8] A=n833
XU366 NAND2XL $PINS Y=n161 B=A[9] A=n821
XU367 OAI21XL $PINS Y=n143 B0=n145 A1=n144 A0=n165
XU368 AOI21X1 $PINS Y=n84 B0=n86 A1=n85 A0=n92
XU369 AOI21X1 $PINS Y=n72 B0=n74 A1=n73 A0=n115
XU370 INVXL $PINS Y=n95 A=n97
XU371 INVXL $PINS Y=n186 A=n187
XU372 AO21X1 $PINS Y=n370 B0=n152 A1=n221 A0=n155
XU373 OAI21XL $PINS Y=n107 B0=n109 A1=n114 A0=n108
XU374 NAND2XL $PINS Y=n4 B=n46 A=n373
XU375 NAND2X1 $PINS Y=n57 B=n371 A=n64
XU376 XOR2X1 $PINS Y=DIFF[6] B=n26 A=n176
XU377 INVXL $PINS Y=n223 A=n163
XU378 NAND2X1 $PINS Y=n198 B=A[1] A=n921
XU379 NOR2X1 $PINS Y=n135 B=A[13] A=n768
XU381 NOR2X1 $PINS Y=n73 B=n96 A=n75
XU382 OAI21XL $PINS Y=n118 B0=n120 A1=n119 A0=n145
XU383 NAND2X1 $PINS Y=n119 B=n121 A=n133
XU384 INVXL $PINS Y=n94 A=n96
XU385 NAND2XL $PINS Y=n144 B=n146 A=n158
XU386 INVXL $PINS Y=n56 A=n58
XU387 XNOR2XL $PINS Y=DIFF[20] B=n12 A=n92
XU388 XOR2XL $PINS Y=DIFF[22] B=n10 A=n84
XU389 XNOR2XL $PINS Y=DIFF[24] B=n8 A=n71
XU390 AOI21XL $PINS Y=n176 B0=n178 A1=n177 A0=n186
XU391 XOR2XL $PINS Y=DIFF[18] B=n14 A=n105
XU392 OAI21XL $PINS Y=n39 B0=n41 A1=n40 A0=n42
XU393 OAI21XL $PINS Y=n74 B0=n76 A1=n75 A0=n97
XU394 OAI21XL $PINS Y=n166 B0=n168 A1=n167 A0=n187
XU395 NAND2XL $PINS Y=n18 B=n129 A=n217
XU396 XNOR2XL $PINS Y=DIFF[30] B=n2 A=n39
XU397 INVXL $PINS Y=n222 A=n160
XU398 NAND2XL $PINS Y=n26 B=n175 A=n225
XU399 INVXL $PINS Y=n225 A=n174
XU400 XOR2XL $PINS Y=DIFF[12] B=n20 A=n142
XU401 NAND2XL $PINS Y=n20 B=n141 A=n219
XU402 XOR2XL $PINS Y=DIFF[8] B=n24 A=n165
XU403 XNOR2X1 $PINS Y=DIFF[13] B=n19 A=n369
XU404 AO21XL $PINS Y=n369 B0=n139 A1=n219 A0=n143
XU405 XNOR2X1 $PINS Y=DIFF[11] B=n21 A=n370
XU406 AOI21XL $PINS Y=n110 B0=n112 A1=n215 A0=n115
XU407 INVXL $PINS Y=n112 A=n114
XU408 NAND2XL $PINS Y=n16 B=n114 A=n215
XU409 XNOR2XL $PINS Y=DIFF[16] B=n16 A=n115
XU410 XNOR2XL $PINS Y=DIFF[28] B=n4 A=n47
XU411 XOR2XL $PINS Y=DIFF[29] B=n3 A=n42
XU412 XOR2XL $PINS Y=DIFF[1] B=n199 A=n31
XU413 INVXL $PINS Y=n230 A=n197
XU414 XOR2XL $PINS Y=DIFF[2] B=n30 A=n195
XU415 AOI21XL $PINS Y=n181 B0=n183 A1=n227 A0=n186
XU416 INVXL $PINS Y=n226 A=n179
XU417 XNOR2XL $PINS Y=DIFF[4] B=n28 A=n186
XU418 NAND2XL $PINS Y=n28 B=n185 A=n227
XU419 INVXL $PINS Y=n228 A=n190
XU420 INVXL $PINS Y=n219 A=n140
XU421 INVXL $PINS Y=n221 A=n153
XU422 INVXL $PINS Y=n217 A=n128
XU423 NAND2BXL $PINS Y=n8 B=n70 AN=n69
XU424 NAND2BXL $PINS Y=n14 B=n104 AN=n103
XU425 NAND2XL $PINS Y=n6 B=n62 A=n371
XU426 INVXL $PINS Y=n139 A=n141
XU427 INVXL $PINS Y=n127 A=n129
XU428 NAND2XL $PINS Y=n136 B=A[13] A=n768
XU429 NAND2XL $PINS Y=n191 B=A[3] A=n896
XU430 NOR2XL $PINS Y=n184 B=A[4] A=FE_PT1_n235
XU431 NOR2XL $PINS Y=n113 B=A[16] A=n738
XU432 NOR2X1 $PINS Y=n108 B=A[17] A=n677
XU433 NOR2X1 $PINS Y=n163 B=A[8] A=n833
XU434 NAND2XL $PINS Y=n67 B=A[25] A=n725
XU435 NAND2XL $PINS Y=n88 B=A[21] A=n624
XU436 NAND2XL $PINS Y=n62 B=A[26] A=n727
XU437 NAND2XL $PINS Y=n180 B=A[5] A=FE_PT1_n236
XU438 NAND2XL $PINS Y=n80 B=A[23] A=n621
XU439 NAND2XL $PINS Y=n53 B=A[27] A=n728
XU440 NAND2XL $PINS Y=n101 B=A[19] A=n582
XU441 NOR2X1 $PINS Y=n90 B=A[20] A=n623
XU442 NOR2X1 $PINS Y=n103 B=A[18] A=n606
XU443 NOR2X1 $PINS Y=n52 B=A[27] A=n728
XU444 NAND2XL $PINS Y=n38 B=A[30] A=n998
XU445 NAND2XL $PINS Y=n46 B=A[28] A=n965
XU446 NAND2XL $PINS Y=n41 B=A[29] A=n978
XU447 OR2XL $PINS Y=n372 B=A[30] A=n998
XU448 OR2XL $PINS Y=n373 B=A[28] A=n965
XU452 NOR2XL $PINS Y=n32 B=A[31] A=n1018
XU453 AND2XL $PINS Y=n374 B=A[31] A=n1018
XU454 XNOR2XL $PINS Y=DIFF[0] B=A[0] A=n943
XU455 CLKINVX1 $PINS Y=n115 A=n116
XU456 CLKINVX1 $PINS Y=n71 A=n72
XU457 CLKINVX1 $PINS Y=n92 A=n93
XU458 OAI21XL $PINS Y=n155 B0=n157 A1=n156 A0=n165
XU459 CLKINVX1 $PINS Y=n165 A=n166
XU460 AOI21X1 $PINS Y=n63 B0=n65 A1=n64 A0=n71
XU461 AOI21X1 $PINS Y=n54 B0=n56 A1=n55 A0=n71
XU462 CLKINVX1 $PINS Y=n55 A=n57
XU463 NAND2X1 $PINS Y=n75 B=n85 A=n77
XU464 XNOR2X1 $PINS Y=DIFF[25] B=n7 A=n68
XU465 XOR2X1 $PINS Y=DIFF[26] B=n6 A=n63
XU466 XOR2X1 $PINS Y=DIFF[27] B=n5 A=n54
XU467 XNOR2X1 $PINS Y=DIFF[21] B=n11 A=n89
XU468 XNOR2X1 $PINS Y=DIFF[23] B=n9 A=n81
XU469 XNOR2X1 $PINS Y=DIFF[19] B=n13 A=n102
XU470 CLKINVX1 $PINS Y=n195 A=n196
XU471 NAND2X1 $PINS Y=n96 B=n106 A=n98
XU472 AOI21X1 $PINS Y=n42 B0=n44 A1=n373 A0=n47
XU473 CLKINVX1 $PINS Y=n44 A=n46
XU474 NAND2X1 $PINS Y=n167 B=n177 A=n169
XU475 AOI21X1 $PINS Y=n168 B0=n170 A1=n169 A0=n178
XU476 AOI21X1 $PINS Y=n58 B0=n60 A1=n371 A0=n65
XU477 CLKINVX1 $PINS Y=n60 A=n62
XU478 AOI21X1 $PINS Y=n97 B0=n99 A1=n98 A0=n107
XU479 OAI21XL $PINS Y=n99 B0=n101 A1=n104 A0=n100
XU480 AOI21X1 $PINS Y=n187 B0=n189 A1=n188 A0=n196
XU481 OAI21XL $PINS Y=n189 B0=n191 A1=n194 A0=n190
XU482 NOR2X1 $PINS Y=n188 B=n190 A=n193
XU483 AOI21X1 $PINS Y=n76 B0=n78 A1=n77 A0=n86
XU484 OAI21XL $PINS Y=n78 B0=n80 A1=n83 A0=n79
XU485 OAI21XL $PINS Y=n147 B0=n149 A1=n154 A0=n148
XU486 NAND2X1 $PINS Y=n48 B=n73 A=n50
XU487 AOI21X1 $PINS Y=n49 B0=n51 A1=n50 A0=n74
XU488 XNOR2X1 $PINS Y=DIFF[10] B=n22 A=n155
XU489 NAND2X1 $PINS Y=n22 B=n154 A=n221
XU490 XNOR2X1 $PINS Y=DIFF[9] B=n23 A=n162
XU491 NAND2X1 $PINS Y=n23 B=n161 A=n222
XU492 OAI21XL $PINS Y=n162 B0=n164 A1=n163 A0=n165
XU493 XNOR2X1 $PINS Y=DIFF[7] B=n25 A=n173
XU494 NAND2X1 $PINS Y=n25 B=n172 A=n224
XU495 OAI21XL $PINS Y=n173 B0=n175 A1=n174 A0=n176
XU496 CLKINVX1 $PINS Y=n224 A=n171
XU497 OAI21XL $PINS Y=n51 B0=n53 A1=n52 A0=n58
XU498 NOR2X1 $PINS Y=n77 B=n82 A=n79
XU499 NOR2X1 $PINS Y=n98 B=n103 A=n100
XU500 NOR2X1 $PINS Y=n85 B=n90 A=n87
XU501 NOR2X1 $PINS Y=n177 B=n184 A=n179
XU502 NOR2X1 $PINS Y=n146 B=n148 A=n153
XU503 NOR2X1 $PINS Y=n121 B=n123 A=n128
XU504 OAI21XL $PINS Y=n68 B0=n70 A1=n69 A0=n72
XU505 OAI21XL $PINS Y=n89 B0=n91 A1=n90 A0=n93
XU506 OAI21XL $PINS Y=n102 B0=n104 A1=n103 A0=n105
XU507 OAI21XL $PINS Y=n81 B0=n83 A1=n82 A0=n84
XU508 AOI21X1 $PINS Y=n34 B0=n36 A1=n372 A0=n39
XU509 CLKINVX1 $PINS Y=n36 A=n38
XU510 AOI21X1 $PINS Y=n120 B0=n122 A1=n121 A0=n134
XU511 OAI21XL $PINS Y=n122 B0=n124 A1=n129 A0=n123
XU512 XOR2X1 $PINS Y=DIFF[31] B=n1 A=n34
XU513 XOR2X1 $PINS Y=DIFF[17] B=n15 A=n110
XU514 NAND2X1 $PINS Y=n15 B=n109 A=n214
XU515 XOR2X1 $PINS Y=DIFF[5] B=n27 A=n181
XU516 NAND2X1 $PINS Y=n27 B=n180 A=n226
XU517 NAND2X1 $PINS Y=n17 B=n124 A=n216
XU518 CLKINVX1 $PINS Y=n216 A=n123
XU519 NAND2X1 $PINS Y=n21 B=n149 A=n220
XU520 CLKINVX1 $PINS Y=n220 A=n148
XU521 NAND2X1 $PINS Y=n19 B=n136 A=n218
XU522 CLKINVX1 $PINS Y=n218 A=n135
XU523 NAND2X1 $PINS Y=n24 B=n164 A=n223
XU524 XNOR2X1 $PINS Y=DIFF[3] B=n29 A=n192
XU525 NAND2X1 $PINS Y=n29 B=n191 A=n228
XU526 OAI21XL $PINS Y=n192 B0=n194 A1=n193 A0=n195
XU527 NOR2X1 $PINS Y=n106 B=n113 A=n108
XU528 NOR2X1 $PINS Y=n64 B=n66 A=n69
XU529 CLKINVX1 $PINS Y=n227 A=n184
XU530 CLKINVX1 $PINS Y=n215 A=n113
XU531 CLKINVX1 $PINS Y=n214 A=n108
XU532 NAND2BX1 $PINS Y=n10 B=n83 AN=n82
XU533 NAND2BX1 $PINS Y=n12 B=n91 AN=n90
XU534 NAND2BX1 $PINS Y=n3 B=n41 AN=n40
XU535 NAND2BX1 $PINS Y=n5 B=n53 AN=n52
XU536 NAND2X1 $PINS Y=n2 B=n38 A=n372
XU537 NAND2BX1 $PINS Y=n13 B=n101 AN=n100
XU538 NAND2BX1 $PINS Y=n11 B=n88 AN=n87
XU539 NAND2BX1 $PINS Y=n9 B=n80 AN=n79
XU540 NAND2BX1 $PINS Y=n7 B=n67 AN=n66
XU541 CLKINVX1 $PINS Y=n183 A=n185
XU542 CLKINVX1 $PINS Y=n152 A=n154
XU543 NAND2X1 $PINS Y=n31 B=n198 A=n230
XU544 NAND2X1 $PINS Y=n30 B=n194 A=n229
XU545 CLKINVX1 $PINS Y=n229 A=n193
XU548 INVXL $PINS Y=n251 A=B[11]
XU551 INVXL $PINS Y=n248 A=B[14]
XU556 NOR2X1 $PINS Y=n190 B=A[3] A=n896
XU557 NOR2X1 $PINS Y=n174 B=A[6] A=FE_PT1_n237
XU558 NOR2X1 $PINS Y=n179 B=A[5] A=FE_PT1_n236
XU559 NAND2X1 $PINS Y=n129 B=A[14] A=n248
XU560 NAND2X1 $PINS Y=n175 B=A[6] A=FE_PT1_n237
XU561 NAND2X1 $PINS Y=n104 B=A[18] A=n606
XU562 NAND2X1 $PINS Y=n141 B=A[12] A=n781
XU563 NAND2X1 $PINS Y=n114 B=A[16] A=n738
XU564 NOR2X1 $PINS Y=n128 B=A[14] A=n248
XU565 NOR2X1 $PINS Y=n140 B=A[12] A=n781
XU566 NOR2X1 $PINS Y=n153 B=A[10] A=n808
XU567 NOR2X1 $PINS Y=n197 B=A[1] A=n921
XU568 NOR2X1 $PINS Y=n199 B=A[0] A=n943
XU569 NOR2X1 $PINS Y=n69 B=A[24] A=n724
XU570 OR2X1 $PINS Y=n371 B=A[26] A=n727
XU571 OR2X1 $PINS Y=n1 B=n374 A=n32
.ENDS

.SUBCKT Execution_DW01_add_1 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29]
+ B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16]
+ B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2]
+ B[1] B[0] CI SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XU269 AOI21XL $PINS Y=n77 B0=n79 A1=n78 A0=n87
XU270 OAI21XL $PINS Y=n87 B0=n89 A1=n92 A0=n88
XU271 NAND2XL $PINS Y=n28 B=n186 A=n229
XU272 INVXL $PINS Y=n184 A=n186
XU273 OAI21XL $PINS Y=n179 B0=n181 A1=n186 A0=n180
XU274 NOR2X1 $PINS Y=n191 B=A[3] A=B[3]
XU275 NAND2X1 $PINS Y=n192 B=A[3] A=B[3]
XU276 NOR2X1 $PINS Y=n175 B=A[6] A=B[6]
XU277 NAND2X1 $PINS Y=n176 B=A[6] A=B[6]
XU278 NOR2X1 $PINS Y=n78 B=n83 A=n80
XU279 AOI21X1 $PINS Y=n188 B0=n190 A1=n189 A0=n197
XU280 OAI21XL $PINS Y=n190 B0=n192 A1=n195 A0=n191
XU281 OAI21XL $PINS Y=n148 B0=n150 A1=n155 A0=n149
XU282 NOR2X1 $PINS Y=n109 B=A[17] A=B[17]
XU283 OAI21XL $PINS Y=n52 B0=n54 A1=n53 A0=n59
XU284 NOR2X1 $PINS Y=n198 B=A[1] A=B[1]
XU285 NOR2X1 $PINS Y=n172 B=A[7] A=B[7]
XU286 NOR2X1 $PINS Y=n101 B=A[19] A=B[19]
XU287 OAI21XL $PINS Y=n108 B0=n110 A1=n115 A0=n109
XU288 NOR2X1 $PINS Y=n80 B=A[23] A=B[23]
XU289 NOR2X1 $PINS Y=n65 B=n67 A=n70
XU290 NOR2X1 $PINS Y=n86 B=n91 A=n88
XU291 NOR2X1 $PINS Y=n53 B=A[27] A=B[27]
XU292 NOR2X1 $PINS Y=n73 B=n75 A=n337
XU293 NAND2X1 $PINS Y=n195 B=A[2] A=B[2]
XU294 OAI21XL $PINS Y=n131 B0=n133 A1=n132 A0=n143
XU295 NOR2X1 $PINS Y=n88 B=A[21] A=B[21]
XU296 NOR2X1 $PINS Y=n91 B=A[20] A=B[20]
XU297 NAND2X1 $PINS Y=n105 B=A[18] A=B[18]
XU298 OR2X1 $PINS Y=n341 B=A[26] A=B[26]
XU299 NOR2X1 $PINS Y=n83 B=A[22] A=B[22]
XU300 AND2X2 $PINS Y=SUM[0] B=n201 A=n344
XU301 NAND2X1 $PINS Y=n142 B=A[12] A=B[12]
XU302 CLKINVX1 $PINS Y=n116 A=n117
XU303 NAND2X1 $PINS Y=n115 B=A[16] A=B[16]
XU304 NOR2X1 $PINS Y=n136 B=A[13] A=B[13]
XU305 NOR2X1 $PINS Y=n104 B=A[18] A=B[18]
XU306 NOR2XL $PINS Y=n114 B=A[16] A=B[16]
XU307 NAND2XL $PINS Y=n137 B=A[13] A=B[13]
XU308 NAND2X1 $PINS Y=n201 B=A[0] A=B[0]
XU309 NAND2XL $PINS Y=n199 B=A[1] A=B[1]
XU310 CLKINVX1 $PINS Y=n72 A=n73
XU311 OAI21XL $PINS Y=n79 B0=n81 A1=n84 A0=n80
XU312 OAI21XL $PINS Y=n69 B0=n71 A1=n70 A0=n73
XU313 NOR2X1 $PINS Y=n67 B=A[25] A=B[25]
XU314 AND2XL $PINS Y=n337 B=n74 A=n116
XU315 OAI21XL $PINS Y=n75 B0=n77 A1=n76 A0=n98
XU316 NOR2X1 $PINS Y=n74 B=n97 A=n76
XU317 NAND2X1 $PINS Y=n120 B=n122 A=n134
XU318 INVXL $PINS Y=n339 A=n87
XU319 NOR2XL $PINS Y=n159 B=n161 A=n164
XU320 NAND2XL $PINS Y=n19 B=n137 A=n220
XU321 INVXL $PINS Y=n220 A=n136
XU322 INVXL $PINS Y=n213 A=n91
XU323 NOR2X1 $PINS Y=n129 B=A[14] A=B[14]
XU324 NAND2XL $PINS Y=n186 B=A[4] A=B[4]
XU325 NAND2XL $PINS Y=n102 B=A[19] A=B[19]
XU326 NAND2X1 $PINS Y=n165 B=A[8] A=B[8]
XU327 NOR2X1 $PINS Y=n164 B=A[8] A=B[8]
XU328 CLKINVX1 $PINS Y=n93 A=n94
XU329 OAI21XL $PINS Y=n119 B0=n121 A1=n120 A0=n146
XU330 NAND2X1 $PINS Y=n145 B=n147 A=n159
XU331 INVXL $PINS Y=n57 A=n59
XU332 INVXL $PINS Y=n196 A=n197
XU333 NAND2X1 $PINS Y=n338 B=n86 A=n93
XU334 AND2X2 $PINS Y=n85 B=n339 A=n338
XU335 AOI21X1 $PINS Y=n121 B0=n123 A1=n122 A0=n135
XU336 NOR2X1 $PINS Y=n122 B=n124 A=n129
XU337 OAI21XL $PINS Y=n135 B0=n137 A1=n142 A0=n136
XU338 OAI21XL $PINS Y=n103 B0=n105 A1=n104 A0=n106
XU339 OAI21XL $PINS Y=n40 B0=n42 A1=n41 A0=n43
XU340 NOR2X1 $PINS Y=n134 B=n136 A=n141
XU341 OAI21XL $PINS Y=n66 B0=n68 A1=n71 A0=n67
XU342 INVXL $PINS Y=n232 A=n198
XU343 OAI21XL $PINS Y=n82 B0=n84 A1=n83 A0=n85
XU344 XOR2X1 $PINS Y=SUM[22] B=n10 A=n85
XU345 INVXL $PINS Y=n56 A=n58
XU346 OAI21XL $PINS Y=n144 B0=n146 A1=n145 A0=n166
XU347 AOI21XL $PINS Y=n177 B0=n179 A1=n178 A0=n187
XU348 AOI21XL $PINS Y=n106 B0=n108 A1=n107 A0=n116
XU349 INVX1 $PINS Y=n166 A=n167
XU350 NAND2XL $PINS Y=n23 B=n162 A=n224
XU351 INVXL $PINS Y=n224 A=n161
XU352 NAND2XL $PINS Y=n25 B=n173 A=n226
XU353 INVXL $PINS Y=n226 A=n172
XU354 NAND2XL $PINS Y=n10 B=n84 A=n211
XU355 INVXL $PINS Y=n211 A=n83
XU356 XOR2XL $PINS Y=SUM[12] B=n20 A=n143
XU357 INVXL $PINS Y=n212 A=n88
XU358 AOI21XL $PINS Y=n111 B0=n113 A1=n217 A0=n116
XU359 NAND2XL $PINS Y=n21 B=n150 A=n222
XU360 INVXL $PINS Y=n222 A=n149
XU361 AOI21XL $PINS Y=n138 B0=n140 A1=n221 A0=n144
XU362 NAND2XL $PINS Y=n17 B=n125 A=n218
XU363 INVXL $PINS Y=n218 A=n124
XU364 NAND2XL $PINS Y=n29 B=n192 A=n230
XU365 INVXL $PINS Y=n230 A=n191
XU366 NAND2XL $PINS Y=n31 B=n199 A=n232
XU367 NAND2XL $PINS Y=n27 B=n181 A=n228
XU368 AOI21XL $PINS Y=n182 B0=n184 A1=n229 A0=n187
XU369 INVXL $PINS Y=n228 A=n180
XU370 XOR2XL $PINS Y=SUM[8] B=n24 A=n166
XU371 INVXL $PINS Y=n225 A=n164
XU372 XOR2XL $PINS Y=SUM[2] B=n30 A=n196
XU373 INVXL $PINS Y=n231 A=n194
XU374 XOR2XL $PINS Y=SUM[6] B=n26 A=n177
XU375 INVXL $PINS Y=n227 A=n175
XU376 XNOR2XL $PINS Y=SUM[4] B=n28 A=n187
XU377 INVXL $PINS Y=n209 A=n70
XU378 INVXL $PINS Y=n216 A=n109
XU379 INVXL $PINS Y=n210 A=n80
XU380 INVXL $PINS Y=n214 A=n101
XU381 INVXL $PINS Y=n206 A=n53
XU382 NAND2XL $PINS Y=n155 B=A[10] A=B[10]
XU383 NOR2XL $PINS Y=n141 B=A[12] A=B[12]
XU384 NAND2XL $PINS Y=n130 B=A[14] A=B[14]
XU385 XNOR2X1 $PINS Y=SUM[31] B=n1 A=n340
XU386 AO21X1 $PINS Y=n340 B0=n37 A1=n342 A0=n40
XU387 NOR2XL $PINS Y=n154 B=A[10] A=B[10]
XU388 NOR2XL $PINS Y=n185 B=A[4] A=B[4]
XU389 NAND2XL $PINS Y=n89 B=A[21] A=B[21]
XU390 NAND2XL $PINS Y=n63 B=A[26] A=B[26]
XU391 NAND2XL $PINS Y=n81 B=A[23] A=B[23]
XU392 NAND2XL $PINS Y=n54 B=A[27] A=B[27]
XU393 NOR2XL $PINS Y=n41 B=A[29] A=B[29]
XU394 NAND2XL $PINS Y=n39 B=A[30] A=B[30]
XU395 NAND2XL $PINS Y=n42 B=A[29] A=B[29]
XU396 OR2XL $PINS Y=n342 B=A[30] A=B[30]
XU397 OR2XL $PINS Y=n345 B=A[31] A=B[31]
XU398 OR2XL $PINS Y=n344 B=A[0] A=B[0]
XU399 CLKINVX1 $PINS Y=n143 A=n144
XU400 AOI21X1 $PINS Y=n94 B0=n96 A1=n95 A0=n116
XU401 CLKINVX1 $PINS Y=n95 A=n97
XU402 CLKINVX1 $PINS Y=n96 A=n98
XU403 AOI21X1 $PINS Y=n117 B0=n119 A1=n118 A0=n167
XU404 NOR2X1 $PINS Y=n118 B=n120 A=n145
XU405 OAI21XL $PINS Y=n156 B0=n158 A1=n157 A0=n166
XU406 CLKINVX1 $PINS Y=n157 A=n159
XU407 CLKINVX1 $PINS Y=n158 A=n160
XU408 CLKINVX1 $PINS Y=n132 A=n134
XU409 CLKINVX1 $PINS Y=n133 A=n135
XU410 AOI21X1 $PINS Y=n64 B0=n66 A1=n65 A0=n72
XU411 AOI21X1 $PINS Y=n55 B0=n57 A1=n56 A0=n72
XU412 CLKINVX1 $PINS Y=n187 A=n188
XU413 NAND2X1 $PINS Y=n76 B=n86 A=n78
XU414 XOR2X1 $PINS Y=SUM[26] B=n6 A=n64
XU415 NAND2X1 $PINS Y=n97 B=n107 A=n99
XU416 OAI21XL $PINS Y=n160 B0=n162 A1=n165 A0=n161
XU417 OAI21XL $PINS Y=n197 B0=n199 A1=n201 A0=n198
XU418 AOI21X1 $PINS Y=n43 B0=n45 A1=n343 A0=n48
XU419 CLKINVX1 $PINS Y=n45 A=n47
XU420 OAI21XL $PINS Y=n167 B0=n169 A1=n168 A0=n188
XU421 NAND2X1 $PINS Y=n168 B=n178 A=n170
XU422 AOI21X1 $PINS Y=n169 B0=n171 A1=n170 A0=n179
XU423 NOR2X1 $PINS Y=n170 B=n172 A=n175
XU424 AOI21X1 $PINS Y=n59 B0=n61 A1=n341 A0=n66
XU425 CLKINVX1 $PINS Y=n61 A=n63
XU426 AOI21X1 $PINS Y=n98 B0=n100 A1=n99 A0=n108
XU427 OAI21XL $PINS Y=n100 B0=n102 A1=n105 A0=n101
XU428 NOR2X1 $PINS Y=n189 B=n191 A=n194
XU429 AOI21X1 $PINS Y=n146 B0=n148 A1=n147 A0=n160
XU430 OAI21XL $PINS Y=n48 B0=n50 A1=n49 A0=n117
XU431 NAND2X1 $PINS Y=n49 B=n74 A=n51
XU432 AOI21X1 $PINS Y=n50 B0=n52 A1=n51 A0=n75
XU433 NOR2X1 $PINS Y=n51 B=n53 A=n58
XU434 XNOR2X1 $PINS Y=SUM[21] B=n11 A=n90
XU435 NAND2X1 $PINS Y=n11 B=n89 A=n212
XU436 OAI21XL $PINS Y=n90 B0=n92 A1=n91 A0=n94
XU437 XNOR2X1 $PINS Y=SUM[10] B=n22 A=n156
XU438 NAND2X1 $PINS Y=n22 B=n155 A=n223
XU439 XNOR2X1 $PINS Y=SUM[14] B=n18 A=n131
XU440 NAND2X1 $PINS Y=n18 B=n130 A=n219
XU441 XNOR2X1 $PINS Y=SUM[9] B=n23 A=n163
XU442 OAI21XL $PINS Y=n163 B0=n165 A1=n164 A0=n166
XU443 XNOR2X1 $PINS Y=SUM[7] B=n25 A=n174
XU444 OAI21XL $PINS Y=n174 B0=n176 A1=n175 A0=n177
XU445 OAI21XL $PINS Y=n171 B0=n173 A1=n176 A0=n172
XU446 NOR2X1 $PINS Y=n178 B=n185 A=n180
XU447 NOR2X1 $PINS Y=n147 B=n149 A=n154
XU448 NOR2X1 $PINS Y=n99 B=n104 A=n101
XU449 CLKINVX1 $PINS Y=n113 A=n115
XU450 OAI21XL $PINS Y=n123 B0=n125 A1=n130 A0=n124
XU451 XOR2X1 $PINS Y=SUM[27] B=n5 A=n55
XU452 NAND2X1 $PINS Y=n5 B=n54 A=n206
XU453 XNOR2X1 $PINS Y=SUM[30] B=n2 A=n40
XU454 NAND2X1 $PINS Y=n2 B=n39 A=n342
XU455 XOR2X1 $PINS Y=SUM[18] B=n14 A=n106
XU456 NAND2X1 $PINS Y=n14 B=n105 A=n215
XU457 XNOR2X1 $PINS Y=SUM[16] B=n16 A=n116
XU458 NAND2X1 $PINS Y=n16 B=n115 A=n217
XU459 XNOR2X1 $PINS Y=SUM[23] B=n9 A=n82
XU460 NAND2X1 $PINS Y=n9 B=n81 A=n210
XU461 XNOR2X1 $PINS Y=SUM[20] B=n12 A=n93
XU462 NAND2X1 $PINS Y=n12 B=n92 A=n213
XU463 XOR2X1 $PINS Y=SUM[17] B=n15 A=n111
XU464 NAND2X1 $PINS Y=n15 B=n110 A=n216
XU465 XNOR2X1 $PINS Y=SUM[19] B=n13 A=n103
XU466 NAND2X1 $PINS Y=n13 B=n102 A=n214
XU467 XNOR2X1 $PINS Y=SUM[28] B=n4 A=n48
XU468 NAND2X1 $PINS Y=n4 B=n47 A=n343
XU469 XNOR2X1 $PINS Y=SUM[24] B=n8 A=n72
XU470 NAND2X1 $PINS Y=n8 B=n71 A=n209
XU471 XOR2X1 $PINS Y=SUM[29] B=n3 A=n43
XU472 NAND2X1 $PINS Y=n3 B=n42 A=n204
XU473 XNOR2X1 $PINS Y=SUM[25] B=n7 A=n69
XU474 NAND2X1 $PINS Y=n7 B=n68 A=n208
XU475 XOR2X1 $PINS Y=SUM[5] B=n27 A=n182
XU476 XOR2X1 $PINS Y=SUM[15] B=n17 A=n126
XU477 AOI21X1 $PINS Y=n126 B0=n128 A1=n219 A0=n131
XU478 NAND2X1 $PINS Y=n20 B=n142 A=n221
XU479 XOR2X1 $PINS Y=SUM[11] B=n21 A=n151
XU480 AOI21X1 $PINS Y=n151 B0=n153 A1=n223 A0=n156
XU481 XOR2X1 $PINS Y=SUM[13] B=n19 A=n138
XU482 NAND2X1 $PINS Y=n26 B=n176 A=n227
XU483 NAND2X1 $PINS Y=n24 B=n165 A=n225
XU484 XNOR2X1 $PINS Y=SUM[3] B=n29 A=n193
XU485 OAI21XL $PINS Y=n193 B0=n195 A1=n194 A0=n196
XU486 NOR2X1 $PINS Y=n107 B=n114 A=n109
XU487 CLKINVX1 $PINS Y=n221 A=n141
XU488 CLKINVX1 $PINS Y=n223 A=n154
XU489 CLKINVX1 $PINS Y=n219 A=n129
XU490 CLKINVX1 $PINS Y=n229 A=n185
XU491 CLKINVX1 $PINS Y=n217 A=n114
XU492 NAND2X1 $PINS Y=n58 B=n341 A=n65
XU493 CLKINVX1 $PINS Y=n215 A=n104
XU494 CLKINVX1 $PINS Y=n208 A=n67
XU495 CLKINVX1 $PINS Y=n140 A=n142
XU496 CLKINVX1 $PINS Y=n153 A=n155
XU497 CLKINVX1 $PINS Y=n128 A=n130
XU498 CLKINVX1 $PINS Y=n204 A=n41
XU499 NAND2X1 $PINS Y=n6 B=n63 A=n341
XU500 CLKINVX1 $PINS Y=n37 A=n39
XU501 XOR2X1 $PINS Y=SUM[1] B=n201 A=n31
XU502 NAND2X1 $PINS Y=n30 B=n195 A=n231
XU503 NOR2X1 $PINS Y=n149 B=A[11] A=B[11]
XU504 NOR2X1 $PINS Y=n161 B=A[9] A=B[9]
XU505 NOR2X1 $PINS Y=n124 B=A[15] A=B[15]
XU506 NOR2X1 $PINS Y=n180 B=A[5] A=B[5]
XU507 NOR2X1 $PINS Y=n194 B=A[2] A=B[2]
XU508 NAND2XL $PINS Y=n150 B=A[11] A=B[11]
XU509 NAND2XL $PINS Y=n162 B=A[9] A=B[9]
XU510 NAND2XL $PINS Y=n125 B=A[15] A=B[15]
XU511 NAND2XL $PINS Y=n173 B=A[7] A=B[7]
XU512 NAND2XL $PINS Y=n181 B=A[5] A=B[5]
XU513 NAND2X1 $PINS Y=n71 B=A[24] A=B[24]
XU514 NAND2X1 $PINS Y=n92 B=A[20] A=B[20]
XU515 NAND2X1 $PINS Y=n110 B=A[17] A=B[17]
XU516 NAND2X1 $PINS Y=n68 B=A[25] A=B[25]
XU517 NAND2X1 $PINS Y=n1 B=n34 A=n345
XU518 NAND2X1 $PINS Y=n34 B=A[31] A=B[31]
XU519 NOR2X1 $PINS Y=n70 B=A[24] A=B[24]
XU520 NAND2X1 $PINS Y=n84 B=A[22] A=B[22]
XU521 NAND2X1 $PINS Y=n47 B=A[28] A=B[28]
XU522 OR2X1 $PINS Y=n343 B=A[28] A=B[28]
.ENDS

.SUBCKT Execution_test_1 clk rst stall ID_WB[1] ID_WB[0] ID_MEM[2] ID_MEM[1]
+ ID_MEM[0] ID_EX[6] ID_EX[5] ID_EX[4] ID_EX[3] ID_EX[2] ID_EX[1] ID_EX[0]
+ RData1[31] RData1[30] RData1[29] RData1[28] RData1[27] RData1[26] RData1[25]
+ RData1[24] RData1[23] RData1[22] RData1[21] RData1[20] RData1[19] RData1[18]
+ RData1[17] RData1[16] RData1[15] RData1[14] RData1[13] RData1[12] RData1[11]
+ RData1[10] RData1[9] RData1[8] RData1[7] RData1[6] RData1[5] RData1[4]
+ RData1[3] RData1[2] RData1[1] RData1[0] RData2[31] RData2[30] RData2[29]
+ RData2[28] RData2[27] RData2[26] RData2[25] RData2[24] RData2[23] RData2[22]
+ RData2[21] RData2[20] RData2[19] RData2[18] RData2[17] RData2[16] RData2[15]
+ RData2[14] RData2[13] RData2[12] RData2[11] RData2[10] RData2[9] RData2[8]
+ RData2[7] RData2[6] RData2[5] RData2[4] RData2[3] RData2[2] RData2[1]
+ RData2[0] Immediate_SE[31] Immediate_SE[30] Immediate_SE[29] Immediate_SE[28]
+ Immediate_SE[27] Immediate_SE[26] Immediate_SE[25] Immediate_SE[24]
+ Immediate_SE[23] Immediate_SE[22] Immediate_SE[21] Immediate_SE[20]
+ Immediate_SE[19] Immediate_SE[18] Immediate_SE[17] Immediate_SE[16]
+ Immediate_SE[15] Immediate_SE[14] Immediate_SE[13] Immediate_SE[12]
+ Immediate_SE[11] Immediate_SE[10] Immediate_SE[9] Immediate_SE[8]
+ Immediate_SE[7] Immediate_SE[6] Immediate_SE[5] Immediate_SE[4]
+ Immediate_SE[3] Immediate_SE[2] Immediate_SE[1] Immediate_SE[0]
+ ID_RegisterRt[4] ID_RegisterRt[3] ID_RegisterRt[2] ID_RegisterRt[1]
+ ID_RegisterRt[0] ID_RegisterRd[4] ID_RegisterRd[3] ID_RegisterRd[2]
+ ID_RegisterRd[1] ID_RegisterRd[0] WB[1] WB[0] MEM[2] MEM[1] MEM[0]
+ next_ALUresult[31] next_ALUresult[30] next_ALUresult[29] next_ALUresult[28]
+ next_ALUresult[27] next_ALUresult[26] next_ALUresult[25] next_ALUresult[24]
+ next_ALUresult[23] next_ALUresult[22] next_ALUresult[21] next_ALUresult[20]
+ next_ALUresult[19] next_ALUresult[18] next_ALUresult[17] next_ALUresult[16]
+ next_ALUresult[15] next_ALUresult[14] next_ALUresult[13] next_ALUresult[12]
+ next_ALUresult[11] next_ALUresult[10] next_ALUresult[9] next_ALUresult[8]
+ next_ALUresult[7] next_ALUresult[6] next_ALUresult[5] next_ALUresult[4]
+ next_ALUresult[3] next_ALUresult[2] next_ALUresult[1] next_ALUresult[0]
+ ALUresult[31] ALUresult[30] ALUresult[29] ALUresult[28] ALUresult[27]
+ ALUresult[26] ALUresult[25] ALUresult[24] ALUresult[23] ALUresult[22]
+ ALUresult[21] ALUresult[20] ALUresult[19] ALUresult[18] ALUresult[17]
+ ALUresult[16] ALUresult[15] ALUresult[14] ALUresult[13] ALUresult[12]
+ ALUresult[11] ALUresult[10] ALUresult[9] ALUresult[8] ALUresult[7]
+ ALUresult[6] ALUresult[5] ALUresult[4] ALUresult[3] ALUresult[2] ALUresult[1]
+ ALUresult[0] MEMWriteData[31] MEMWriteData[30] MEMWriteData[29]
+ MEMWriteData[28] MEMWriteData[27] MEMWriteData[26] MEMWriteData[25]
+ MEMWriteData[24] MEMWriteData[23] MEMWriteData[22] MEMWriteData[21]
+ MEMWriteData[20] MEMWriteData[19] MEMWriteData[18] MEMWriteData[17]
+ MEMWriteData[16] MEMWriteData[15] MEMWriteData[14] MEMWriteData[13]
+ MEMWriteData[12] MEMWriteData[11] MEMWriteData[10] MEMWriteData[9]
+ MEMWriteData[8] MEMWriteData[7] MEMWriteData[6] MEMWriteData[5]
+ MEMWriteData[4] MEMWriteData[3] MEMWriteData[2] MEMWriteData[1]
+ MEMWriteData[0] RegisterRd[4] RegisterRd[3] RegisterRd[2] RegisterRd[1]
+ RegisterRd[0] WBData[31] WBData[30] WBData[29] WBData[28] WBData[27]
+ WBData[26] WBData[25] WBData[24] WBData[23] WBData[22] WBData[21] WBData[20]
+ WBData[19] WBData[18] WBData[17] WBData[16] WBData[15] WBData[14] WBData[13]
+ WBData[12] WBData[11] WBData[10] WBData[9] WBData[8] WBData[7] WBData[6]
+ WBData[5] WBData[4] WBData[3] WBData[2] WBData[1] WBData[0] ForwardA[1]
+ ForwardA[0] ForwardB[1] ForwardB[0] test_si test_so test_se SPCASCAN_N0
+ FE_PT1_ICACHE_addr_i_21_ SPCASCAN_N8 FE_PT1_ICACHE_addr_i_22_ SPCASCAN_N9
+ SPCASCAN_N10 SPCASCAN_N11 SPCASCAN_N12 SPCASCAN_N16 SPCASCAN_N17 SPCASCAN_N21
+ SPCASCAN_N22 FE_OFN15_test_se_i FE_OFN21_test_se_i FE_OFN8_test_se_i
+ SPCBSCAN_N39 FE_OFN93_test_se_i FE_OFN94_test_se_i FE_OFN96_test_se_i
+ FE_OFN97_test_se_i clk_i__L3_N11 clk_i__L3_N2 clk_i__L3_N9
XLTIE_LTIELO TIELO $PINS Y=LTIE_LTIELO_NET
XFE_OFC224_n709 CLKBUFX2 $PINS Y=FE_OFN224_n709 A=n709
XFE_OFC210_n245 CLKBUFX2 $PINS Y=FE_OFN210_n245 A=n245
XFE_OFC205_n249 CLKBUFX2 $PINS Y=FE_OFN205_n249 A=n249
XFE_OFC176_n273 CLKBUFX2 $PINS Y=FE_OFN176_n273 A=n273
XFE_OFC175_n6 CLKBUFX2 $PINS Y=FE_OFN175_n6 A=n6
XFE_OFC174_n789 CLKBUFX2 $PINS Y=FE_OFN174_n789 A=n789
XFE_OFC173_n283 CLKBUFX2 $PINS Y=FE_OFN173_n283 A=n283
XFE_OFC172_n281 CLKBUFX2 $PINS Y=FE_OFN172_n281 A=FE_OFN171_n281
XFE_OFC171_n281 CLKBUFX2 $PINS Y=FE_OFN171_n281 A=n933
XFE_OFC170_n1018 CLKBUFX2 $PINS Y=FE_OFN170_n1018 A=n1018
XFE_OFC167_n343 CLKBUFX3 $PINS Y=FE_OFN167_n343 A=n341
XFE_OFC166_n342 CLKBUFX2 $PINS Y=FE_OFN166_n342 A=n341
XFE_OFC165_n341 CLKBUFX3 $PINS Y=FE_OFN165_n341 A=n341
XFE_OFC135_n332 CLKBUFX2 $PINS Y=FE_OFN135_n332 A=n332
XFE_OFC134_n319 CLKBUFX2 $PINS Y=FE_OFN134_n319 A=n319
XFE_OFC133_n299 CLKBUFX2 $PINS Y=FE_OFN133_n299 A=n997
XFE_OFC132_n284 CLKBUFX2 $PINS Y=FE_OFN132_n284 A=n982
XFE_OFC131_n302 CLKBUFX2 $PINS Y=FE_OFN131_n302 A=n302
XFE_OFC130_n303 CLKBUFX2 $PINS Y=FE_OFN130_n303 A=n303
XFE_OFC129_n306 CLKBUFX2 $PINS Y=FE_OFN129_n306 A=n451
XFE_OFC128_n293 CLKBUFX2 $PINS Y=FE_OFN128_n293 A=n293
XFE_OFC127_n288 CLKBUFX2 $PINS Y=FE_OFN127_n288 A=FE_OFN126_n288
XFE_OFC126_n288 CLKBUFX2 $PINS Y=FE_OFN126_n288 A=n288
XFE_OFC98_test_se_i CLKBUFX2 $PINS Y=FE_OFN98_test_se_i A=FE_OFN97_test_se_i
XFE_OFC95_test_se_i CLKBUFX2 $PINS Y=FE_OFN95_test_se_i A=FE_OFN94_test_se_i
XU3 BUFX2 $PINS Y=n108 A=ALUData2[14]
XU4 CLKBUFX3 $PINS Y=n277 A=n275
XU5 CLKBUFX3 $PINS Y=n5 A=ALUData2[0]
XU6 OAI221XL $PINS Y=ALUData2[0] C0=n934 B1=n1120 B0=n250 A1=n283 A0=n1149
XU11 BUFX2 $PINS Y=n6 A=n135
XU12 AND2XL $PINS Y=n135 B=n361 A=n362
XU13 OAI221XL $PINS Y=ALUData2[14] C0=n750 B1=n280 B0=n1095 A1=FE_OFN172_n281
+ A0=n1060
XU14 CLKBUFX3 $PINS Y=n280 A=n279
XU15 OAI221X1 $PINS Y=ALUData1[3] C0=n890 B1=n273 B0=n1071 A1=n275 A0=n1153
XU16 NAND2X1 $PINS Y=n932 B=n357 A=n352
XU17 OR2X1 $PINS Y=n356 B=ForwardB[1] A=ID_EX[0]
XU18 CLKBUFX3 $PINS Y=n252 A=ALUData2[30]
XU19 CLKBUFX3 $PINS Y=n254 A=ALUData2[28]
XU20 CLKBUFX3 $PINS Y=n264 A=ALUData2[21]
XU21 CLKBUFX3 $PINS Y=n266 A=ALUData2[19]
XU22 CLKBUFX3 $PINS Y=n267 A=ALUData2[18]
XU23 CLKBUFX3 $PINS Y=n262 A=ALUData2[23]
XU24 INVX1 $PINS Y=n725 A=n260
XU25 CLKBUFX3 $PINS Y=n263 A=ALUData2[22]
XU26 CLKBUFX3 $PINS Y=n255 A=ALUData2[27]
XU27 CLKINVX1 $PINS Y=n980 A=n995
XU28 CLKBUFX3 $PINS Y=n259 A=ALUData2[26]
XU29 CLKBUFX3 $PINS Y=n257 A=n998
XU30 NAND2XL $PINS Y=n426 B=n6 A=RData1[24]
XU31 INVX1 $PINS Y=n724 A=n261
XU32 OR3X2 $PINS Y=ALUData2[13] C=n101 B=n100 A=n99
XU33 CLKINVX1 $PINS Y=n101 A=n763
XU34 CLKINVX1 $PINS Y=n361 A=ForwardA[0]
XU35 CLKINVX1 $PINS Y=n362 A=ForwardA[1]
XU36 OAI221X1 $PINS Y=ALUData2[11] C0=n790 B1=n280 B0=n1098 A1=FE_OFN172_n281
+ A0=n1063
XU37 CLKINVX1 $PINS Y=n316 A=Immediate_SE[9]
XU38 OR2X1 $PINS Y=n295 B=n313 A=n312
XU39 NOR3X1 $PINS Y=n358 C=n308 B=n315 A=n317
XU40 NOR3X1 $PINS Y=n359 C=n317 B=n315 A=n307
XU41 CLKINVX1 $PINS Y=n318 A=Immediate_SE[10]
XU42 BUFX2 $PINS Y=n283 A=n936
XU43 CLKINVX1 $PINS Y=n308 A=Immediate_SE[6]
XU44 CLKINVX1 $PINS Y=n310 A=Immediate_SE[7]
XU45 OR3X2 $PINS Y=ALUData2[8] C=n7 B=n107 A=n105
XU46 MXI3X1 $PINS Y=n192 S1=n246 S0=FE_OFN205_n249 C=n193 B=n236 A=n235
XU47 CLKINVX1 $PINS Y=n621 A=n262
XU48 CLKBUFX3 $PINS Y=n253 A=ALUData2[29]
XU49 CLKINVX1 $PINS Y=n728 A=n255
XU50 CLKINVX1 $PINS Y=n1071 A=WBData[3]
XU51 CLKINVX1 $PINS Y=n1066 A=WBData[8]
XU52 CLKINVX1 $PINS Y=n1062 A=WBData[12]
XU53 CLKINVX1 $PINS Y=n1059 A=WBData[15]
XU54 AO22X1 $PINS Y=n849 B1=n150 B0=N371 A1=n148 A0=N179
XU55 NAND4BX1 $PINS Y=next_ALUresult[30] D=n1004 C=n1005 B=n1006 AN=n1007
XU56 NAND4BX1 $PINS Y=next_ALUresult[17] D=n715 C=n716 B=n717 AN=n718
XU57 NAND4BX1 $PINS Y=next_ALUresult[20] D=n566 C=n567 B=n568 AN=n569
XU58 NAND4BX1 $PINS Y=next_ALUresult[21] D=n547 C=n548 B=n550 AN=n551
XU59 AOI221XL $PINS Y=n547 C0=n546 B1=n148 B0=N193 A1=n150 A0=N385
XU60 NAND4X1 $PINS Y=next_ALUresult[0] D=n947 C=n948 B=n949 A=n113
XU61 NAND4X1 $PINS Y=next_ALUresult[15] D=n958 C=n959 B=n960 A=n110
XU62 NAND4X1 $PINS Y=next_ALUresult[12] D=n785 C=n786 B=n787 A=n115
XU63 NAND4BX1 $PINS Y=next_ALUresult[19] D=n587 C=n588 B=n589 AN=n590
XU64 NAND4BX1 $PINS Y=next_ALUresult[18] D=n611 C=n612 B=n613 AN=n614
XU65 NAND4BX1 $PINS Y=next_ALUresult[23] D=n487 C=n489 B=n490 AN=n492
XU66 NAND4BX1 $PINS Y=next_ALUresult[26] D=n405 C=n406 B=n407 AN=n408
XU67 CLKMX2X2 $PINS Y=next_ALUresult[31] S0=n320 B=ALUresult[31] A=n1026
XU68 NAND3BX1 $PINS Y=n1026 C=n1023 B=n1024 AN=n1025
XU69 NAND4BX1 $PINS Y=next_ALUresult[25] D=n422 C=n423 B=n424 AN=n425
XU70 NAND4BX1 $PINS Y=next_ALUresult[22] D=n516 C=n517 B=n519 AN=n520
XU71 AOI221XL $PINS Y=n516 C0=n514 B1=n298 B0=N194 A1=n150 A0=N386
XU72 NAND4BX1 $PINS Y=next_ALUresult[27] D=n390 C=n391 B=n392 AN=n393
XU73 NAND4BX1 $PINS Y=next_ALUresult[24] D=n460 C=n462 B=n463 AN=n465
XU74 NAND4X1 $PINS Y=next_ALUresult[13] D=n772 C=n773 B=n774 A=n119
XU75 NAND4X1 $PINS Y=next_ALUresult[11] D=n799 C=n800 B=n801 A=n112
XU76 NAND4X1 $PINS Y=next_ALUresult[14] D=n759 C=n760 B=n761 A=n111
XU77 CLKBUFX2 $PINS Y=n279 A=n932
XU78 CLKINVX1 $PINS Y=n235 A=ALUData2[4]
XU79 CLKBUFX3 $PINS Y=n273 A=n930
XU80 CLKINVX1 $PINS Y=n896 A=ALUData2[3]
XU81 CLKINVX1 $PINS Y=n234 A=ALUData2[2]
XU82 NAND2X1 $PINS Y=n936 B=n356 A=n357
XU83 CLKINVX1 $PINS Y=n789 A=n250
XU84 OAI22XL $PINS Y=n7 B1=n280 B0=n1101 A1=FE_OFN172_n281 A0=n1066
XU85 CLKBUFX3 $PINS Y=n251 A=ALUData2[31]
XU86 NAND3X1 $PINS Y=ALUData2[1] C=n916 B=n103 A=n102
XU87 CLKINVX1 $PINS Y=n347 A=ID_EX[0]
XU88 MXI2X1 $PINS Y=n8 S0=n246 B=n207 A=n208
XU89 MXI2X1 $PINS Y=n9 S0=n246 B=n211 A=n212
XU90 MXI2X1 $PINS Y=n10 S0=n246 B=n217 A=n218
XU91 CLKINVX1 $PINS Y=n236 A=ALUData2[5]
XU92 CLKINVX1 $PINS Y=n1118 A=Immediate_SE[2]
XU93 CLKINVX1 $PINS Y=n1119 A=Immediate_SE[1]
XU94 CLKINVX1 $PINS Y=n1120 A=Immediate_SE[0]
XU95 CLKINVX1 $PINS Y=n997 A=n535
XU96 NAND2X1 $PINS Y=n186 B=n359 A=n348
XU97 CLKINVX1 $PINS Y=n307 A=n308
XU98 INVX12 $PINS Y=MEMWriteData[16] A=n26
XU99 INVX12 $PINS Y=MEMWriteData[20] A=n25
XU100 INVX12 $PINS Y=MEMWriteData[18] A=n24
XU101 INVX12 $PINS Y=MEMWriteData[17] A=n23
XU102 INVX12 $PINS Y=MEMWriteData[2] A=n35
XU103 INVX12 $PINS Y=MEMWriteData[3] A=n34
XU104 INVX12 $PINS Y=MEMWriteData[4] A=n33
XU105 INVX12 $PINS Y=MEMWriteData[5] A=n32
XU106 INVX12 $PINS Y=MEMWriteData[6] A=n31
XU107 INVX12 $PINS Y=MEMWriteData[7] A=n30
XU108 INVX12 $PINS Y=MEMWriteData[8] A=n29
XU109 INVX12 $PINS Y=MEMWriteData[9] A=n28
XU110 INVX12 $PINS Y=MEMWriteData[10] A=n27
XU111 INVX12 $PINS Y=MEMWriteData[11] A=n22
XU112 INVX12 $PINS Y=MEMWriteData[12] A=n21
XU113 INVX12 $PINS Y=MEMWriteData[13] A=n20
XU114 INVX12 $PINS Y=MEMWriteData[14] A=n19
XU115 INVX12 $PINS Y=MEMWriteData[15] A=n18
XU116 INVX12 $PINS Y=MEMWriteData[26] A=n17
XU117 INVX12 $PINS Y=MEMWriteData[25] A=n16
XU118 INVX12 $PINS Y=MEMWriteData[24] A=n15
XU119 INVX12 $PINS Y=MEMWriteData[23] A=n14
XU120 INVX12 $PINS Y=MEMWriteData[22] A=n13
XU121 INVX12 $PINS Y=MEMWriteData[21] A=n12
XU122 INVX12 $PINS Y=MEMWriteData[19] A=n11
XU123 CLKINVX1 $PINS Y=n61 A=n990
XU124 INVX16 $PINS Y=ALUresult[30] A=n61
XU125 CLKINVX1 $PINS Y=n63 A=n617
XU126 INVX16 $PINS Y=ALUresult[17] A=n63
XU127 CLKINVX1 $PINS Y=n65 A=n880
XU128 INVX16 $PINS Y=ALUresult[4] A=n65
XU129 CLKINVX1 $PINS Y=n67 A=n721
XU130 INVX16 $PINS Y=ALUresult[16] A=n67
XU131 CLKINVX1 $PINS Y=n69 A=n974
XU132 INVX16 $PINS Y=ALUresult[29] A=n69
XU133 CLKINVX1 $PINS Y=n71 A=n961
XU134 INVX16 $PINS Y=ALUresult[28] A=n71
XU135 CLKINVX1 $PINS Y=n73 A=n554
XU136 INVX16 $PINS Y=ALUresult[20] A=n73
XU137 CLKINVX1 $PINS Y=n75 A=n524
XU138 INVX16 $PINS Y=ALUresult[21] A=n75
XU139 CLKINVX1 $PINS Y=n77 A=n829
XU140 INVX16 $PINS Y=ALUresult[8] A=n77
XU141 CLKINVX1 $PINS Y=n79 A=n917
XU142 INVX16 $PINS Y=ALUresult[1] A=n79
XU143 OAI221X4 $PINS Y=ALUData2[7] C0=n841 B1=n310 B0=n250 A1=FE_OFN173_n283
+ A0=n1174
XU144 OAI221X4 $PINS Y=ALUData2[6] C0=n854 B1=n308 B0=n250 A1=FE_OFN173_n283
+ A0=n1186
XU145 OAI221X4 $PINS Y=ALUData2[5] C0=n866 B1=n867 B0=n250 A1=n283 A0=n1177
XU146 OA22XL $PINS Y=n866 B1=n279 B0=n1104 A1=FE_OFN171_n281 A0=n1069
XU147 OAI221X4 $PINS Y=ALUData2[3] C0=n891 B1=n1117 B0=n250 A1=n283 A0=n1153
XU148 OA22XL $PINS Y=n891 B1=n279 B0=n1106 A1=FE_OFN171_n281 A0=n1071
XU149 OAI221X4 $PINS Y=ALUData2[2] C0=n904 B1=n1118 B0=n250 A1=n283 A0=n1183
XU150 OAI221X4 $PINS Y=ALUData2[15] C0=n748 B1=n280 B0=n1094 A1=FE_OFN172_n281
+ A0=n1059
XU151 OAI221X4 $PINS Y=ALUData2[9] C0=n816 B1=n316 B0=n250 A1=FE_OFN173_n283
+ A0=n1171
XU152 OA22XL $PINS Y=n816 B1=n279 B0=n1100 A1=FE_OFN172_n281 A0=n1065
XU153 OAI221X4 $PINS Y=ALUData2[12] C0=n776 B1=n280 B0=n1097 A1=FE_OFN171_n281
+ A0=n1062
XU154 OAI221X4 $PINS Y=ALUData2[10] C0=n803 B1=n318 B0=n250 A1=FE_OFN173_n283
+ A0=n1180
XU155 OA22XL $PINS Y=n803 B1=n279 B0=n1099 A1=FE_OFN172_n281 A0=n1064
XU156 INVX12 $PINS Y=MEMWriteData[0] A=n892
XU157 INVX12 $PINS Y=MEMWriteData[31] A=n1041
XU158 INVX12 $PINS Y=MEMWriteData[30] A=n1133
XU159 INVX12 $PINS Y=MEMWriteData[29] A=n1136
XU161 INVX12 $PINS Y=MEMWriteData[28] A=n1139
XU162 INVX12 $PINS Y=MEMWriteData[27] A=n1142
XU163 BUFX16 $PINS Y=ALUresult[0] A=n1128
XU164 INVX16 $PINS Y=ALUresult[9] A=n104
XU165 INVX16 $PINS Y=ALUresult[15] A=n94
XU166 NAND4X1 $PINS Y=next_ALUresult[7] D=n850 C=n851 B=n852 A=n116
XU167 INVX16 $PINS Y=ALUresult[7] A=n704
XU168 INVX16 $PINS Y=ALUresult[12] A=n95
XU169 BUFX16 $PINS Y=ALUresult[19] A=n1126
XU170 BUFX16 $PINS Y=ALUresult[18] A=n1127
XU171 NAND4X1 $PINS Y=next_ALUresult[4] D=n887 C=n888 B=n889 A=n123
XU172 BUFX16 $PINS Y=ALUresult[23] A=n1124
XU173 NAND4BX1 $PINS Y=next_ALUresult[16] D=n743 C=n744 B=n745 AN=n746
XU174 BUFX16 $PINS Y=ALUresult[26] A=n1123
XU175 BUFX16 $PINS Y=ALUresult[31] A=n1121
XU176 NAND4BX1 $PINS Y=next_ALUresult[29] D=n986 C=n987 B=n988 AN=n989
XU177 NAND4BX1 $PINS Y=next_ALUresult[28] D=n970 C=n971 B=n972 AN=n973
XU178 BUFX16 $PINS Y=ALUresult[25] A=n411
XU179 INVX16 $PINS Y=ALUresult[5] A=n706
XU180 BUFX16 $PINS Y=ALUresult[22] A=n1125
XU181 BUFX16 $PINS Y=ALUresult[27] A=n1122
XU182 BUFX16 $PINS Y=ALUresult[24] A=n430
XU183 NAND4X1 $PINS Y=next_ALUresult[10] D=n812 C=n813 B=n814 A=n114
XU184 INVX16 $PINS Y=ALUresult[10] A=n700
XU185 NAND4X1 $PINS Y=next_ALUresult[2] D=n912 C=n913 B=n914 A=n122
XU186 INVX16 $PINS Y=ALUresult[2] A=FE_OFN224_n709
XU187 NAND4X1 $PINS Y=next_ALUresult[3] D=n900 C=n901 B=n902 A=n121
XU188 INVX16 $PINS Y=ALUresult[3] A=n708
XU189 NAND4X1 $PINS Y=next_ALUresult[8] D=n837 C=n838 B=n839 A=n117
XU190 NAND4X1 $PINS Y=next_ALUresult[6] D=n862 C=n863 B=n864 A=n118
XU191 INVX16 $PINS Y=ALUresult[6] A=n705
XU192 INVX16 $PINS Y=ALUresult[13] A=n96
XU193 INVX16 $PINS Y=ALUresult[11] A=n97
XU194 INVX16 $PINS Y=ALUresult[14] A=n696
XU195 CLKINVX1 $PINS Y=n1069 A=WBData[5]
XU196 CLKINVX1 $PINS Y=n1064 A=WBData[10]
XU197 CLKINVX1 $PINS Y=n1072 A=WBData[2]
XU198 CLKINVX1 $PINS Y=n1067 A=WBData[7]
XU199 CLKINVX1 $PINS Y=n1068 A=WBData[6]
XU200 NAND2XL $PINS Y=n802 B=FE_OFN175_n6 A=RData1[10]
XU201 MXI2X1 $PINS Y=n184 S0=Immediate_SE[8] B=n137 A=n144
XU203 AOI2BB2XL $PINS Y=n776 B1=FE_OFN174_n789 B0=Immediate_SE[12]
+ A1N=FE_OFN173_n283 A0N=n1159
XU204 NAND2XL $PINS Y=n929 B=FE_OFN175_n6 A=RData1[0]
XU205 OA22XL $PINS Y=n916 B1=n1040 B0=n279 A1=n1039 A0=FE_OFN171_n281
XU206 OR2XL $PINS Y=n102 B=n283 A=n710
XU207 OR2XL $PINS Y=n103 B=n1119 A=n250
XU208 NOR2XL $PINS Y=n99 B=FE_OFN171_n281 A=n1061
XU209 NOR2XL $PINS Y=n100 B=n280 A=n1096
XU210 OAI222XL $PINS Y=n531 C1=n621 C0=n130 B1=n725 B0=n157 A1=n724 A0=n158
XU211 AOI22X1 $PINS Y=n123 B1=n152 B0=N208 A1=n287 A0=N336
XU212 AOI2BB2XL $PINS Y=n763 B1=n789 B0=Immediate_SE[13] A1N=n283 A0N=n1162
XU213 MXI4X1 $PINS Y=n145 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n225 B=n224
+ A=n226
XU214 AND2X2 $PINS Y=n109 B=n980 A=n106
XU215 AO22X1 $PINS Y=n771 B1=n297 B0=N377 A1=n298 A0=N185
XU216 MXI4X1 $PINS Y=n147 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n210 B=n209
+ A=n204
XU217 MXI2X1 $PINS Y=N498 S0=Immediate_SE[7] B=n187 A=n191
XU218 MXI4X1 $PINS Y=n126 S1=Immediate_SE[9] S0=n245 D=n224 C=n226 B=n225
+ A=n229
XU219 CLKINVX1 $PINS Y=n1049 A=WBData[25]
XU220 OA22X1 $PINS Y=n904 B1=n279 B0=n1107 A1=FE_OFN171_n281 A0=n1072
XU221 NOR2XL $PINS Y=n105 B=FE_OFN173_n283 A=n703
XU222 CLKINVX1 $PINS Y=n1105 A=RData2[4]
XU223 CLKINVX1 $PINS Y=n314 A=Immediate_SE[8]
XU224 CLKINVX1 $PINS Y=n982 A=n541
XU225 NAND2X1 $PINS Y=n537 B=FE_OFN135_n332 A=n1020
XU226 NAND2X1 $PINS Y=n992 B=FE_OFN135_n332 A=n1016
XU227 CLKINVX1 $PINS Y=n376 A=n383
XU228 MXI2X1 $PINS Y=N501 S0=Immediate_SE[7] B=n182 A=n184
XU229 MXI2X1 $PINS Y=N499 S0=n309 B=n184 A=n188
XU230 AOI2BB1X1 $PINS Y=n823 B0=n821 A1N=n822 A0N=FE_OFN127_n288
XU231 MX2XL $PINS Y=n406 S0=n400 B=n396 A=n397
XU232 MX2XL $PINS Y=n588 S0=n581 B=n572 A=n573
XU233 NAND4X1 $PINS Y=next_ALUresult[5] D=n875 C=n876 B=n877 A=n124
XU234 AOI22X1 $PINS Y=n124 B1=n152 B0=N209 A1=n287 A0=N337
XU235 AOI22X1 $PINS Y=n119 B1=n152 B0=N217 A1=n287 A0=N345
XU236 NAND4X1 $PINS Y=next_ALUresult[9] D=n825 C=n826 B=n827 A=n120
XU237 AOI22X1 $PINS Y=n120 B1=n152 B0=N213 A1=n287 A0=N341
XU238 MX2XL $PINS Y=n971 S0=n964 B=n962 A=n963
XU239 NOR2BX1 $PINS Y=n155 B=n1013 AN=n428
XU240 INVX1 $PINS Y=n309 A=n310
XU241 CLKINVX1 $PINS Y=n940 A=n381
XU242 NAND3BX1 $PINS Y=n382 C=n1013 B=n940 AN=n939
XU243 CLKINVX1 $PINS Y=n380 A=n428
XU244 AOI211XL $PINS Y=n442 C0=ID_EX[1] B0=ID_EX[3] A1=n443 A0=Immediate_SE[2]
XU245 NAND2XL $PINS Y=n443 B=n1119 A=Immediate_SE[5]
XU246 INVX1 $PINS Y=n1096 A=RData2[13]
XU247 INVX1 $PINS Y=n1094 A=RData2[15]
XU248 INVX1 $PINS Y=n1097 A=RData2[12]
XU249 INVX1 $PINS Y=n1101 A=RData2[8]
XU250 INVX1 $PINS Y=n1099 A=RData2[10]
XU251 INVX1 $PINS Y=n1100 A=RData2[9]
XU252 INVX1 $PINS Y=n1106 A=RData2[3]
XU253 INVX1 $PINS Y=n1104 A=RData2[5]
XU254 INVX1 $PINS Y=n1103 A=RData2[6]
XU255 INVX1 $PINS Y=n1102 A=RData2[7]
XU256 NOR2XL $PINS Y=n107 B=n314 A=n250
XU257 CLKBUFX3 $PINS Y=n250 A=n935
XU258 MXI2X1 $PINS Y=n165 S0=Immediate_SE[8] B=n8 A=n241
XU259 NAND2X1 $PINS Y=n792 B=n795 A=n296
XU260 CLKINVX1 $PINS Y=n1110 A=n329
XU261 AO22X1 $PINS Y=n957 B1=n150 B0=N379 A1=n148 A0=N187
XU262 MXI2X1 $PINS Y=N505 S0=Immediate_SE[7] B=n169 A=n178
XU263 AO21X1 $PINS Y=n1022 B0=n154 A1=n1012 A0=N203
XU264 MXI2X1 $PINS Y=N506 S0=Immediate_SE[7] B=n174 A=n173
XU265 NAND2XL $PINS Y=n931 B=n361 A=ForwardA[1]
XU266 MXI2X1 $PINS Y=n188 S0=Immediate_SE[8] B=n146 A=n126
XU267 MXI2X1 $PINS Y=N495 S0=Immediate_SE[7] B=n194 A=n202
XU268 AOI2BB1X1 $PINS Y=n910 B0=n234 A1N=n909 A0N=FE_OFN126_n288
XU269 MXI2X1 $PINS Y=N497 S0=Immediate_SE[7] B=n188 A=n194
XU270 AOI2BB1X1 $PINS Y=n885 B0=n235 A1N=n884 A0N=FE_OFN126_n288
XU271 AOI2BB1X1 $PINS Y=n835 B0=n833 A1N=n834 A0N=FE_OFN127_n288
XU272 MXI2X1 $PINS Y=N496 S0=Immediate_SE[7] B=n191 A=n199
XU273 AOI2BB1X1 $PINS Y=n898 B0=n896 A1N=n897 A0N=FE_OFN126_n288
XU274 AOI2BB1X1 $PINS Y=n848 B0=n846 A1N=n847 A0N=FE_OFN127_n288
XU275 AOI2BB1X1 $PINS Y=n860 B0=n237 A1N=n859 A0N=FE_OFN126_n288
XU276 MXI2X1 $PINS Y=N502 S0=Immediate_SE[7] B=n181 A=n183
XU277 AO22X1 $PINS Y=n946 B1=n297 B0=N364 A1=n148 A0=N172
XU278 NAND2X1 $PINS Y=n951 B=n954 A=n149
XU279 NAND2X1 $PINS Y=n752 B=n755 A=n296
XU280 MX2XL $PINS Y=n517 S0=n507 B=n496 A=n498
XU281 MX2XL $PINS Y=n462 S0=n449 B=n432 A=n436
XU282 MX2XL $PINS Y=n423 S0=n416 B=n412 A=n413
XU283 MX2XL $PINS Y=n1005 S0=n996 B=n993 A=n994
XU284 MX2XL $PINS Y=n489 S0=n478 B=n469 A=n471
XU285 MX2XL $PINS Y=n548 S0=n534 B=n525 A=n526
XU286 MX2XL $PINS Y=n567 S0=n561 B=n555 A=n556
XU287 MX2XL $PINS Y=n391 S0=n385 B=n374 A=n375
XU288 NAND2XL $PINS Y=n930 B=n362 A=ForwardA[0]
XU289 CLKMX2X2 $PINS Y=n125 S0=n245 B=n8 A=n189
XU290 INVXL $PINS Y=n998 A=n252
XU291 INVX1 $PINS Y=n1046 A=WBData[28]
XU292 INVX1 $PINS Y=n1045 A=WBData[29]
XU293 NAND3BXL $PINS Y=n1009 C=n1013 B=n940 AN=n380
XU294 INVX3 $PINS Y=n317 A=n318
XU295 NAND3BXL $PINS Y=n379 C=n1013 B=n381 AN=n1014
XU296 NAND3BXL $PINS Y=n373 C=n381 B=n155 AN=n1014
XU297 AND2XL $PINS Y=n159 B=n380 A=n381
XU298 AND2XL $PINS Y=n160 B=n381 A=n153
XU299 AND2XL $PINS Y=n161 B=n380 A=n1013
XU300 NAND2X1 $PINS Y=n915 B=FE_OFN175_n6 A=RData1[1]
XU301 NAND2X1 $PINS Y=n878 B=FE_OFN175_n6 A=RData1[4]
XU302 NAND2XL $PINS Y=n890 B=FE_OFN175_n6 A=RData1[3]
XU303 MX2XL $PINS Y=n1024 S0=n1015 B=n1010 A=n1011
XU304 CLKINVX1 $PINS Y=n1107 A=RData2[2]
XU305 CLKINVX1 $PINS Y=n1040 A=RData2[1]
XU306 CLKINVX1 $PINS Y=n1036 A=RData2[0]
XU307 AND2XL $PINS Y=n456 B=n980 A=n185
XU308 AND2XL $PINS Y=n419 B=n980 A=n168
XU309 AO22X1 $PINS Y=n403 B1=n297 B0=N390 A1=n298 A0=N198
XU310 MXI2XL $PINS Y=n194 S0=Immediate_SE[8] B=n144 A=n244
XU311 INVXL $PINS Y=n244 A=n230
XU312 AOI2BB1XL $PINS Y=n1003 B0=n109 A1N=n995 A0N=n139
XU313 INVXL $PINS Y=n729 A=n313
XU314 AOI2BB1XL $PINS Y=n1021 B0=n1018 A1N=n1019 A0N=n1020
XU315 AO22X1 $PINS Y=n484 B1=n297 B0=N387 A1=n298 A0=N195
XU316 INVXL $PINS Y=n513 A=n214
XU317 INVXL $PINS Y=n544 A=n231
XU318 MXI3XL $PINS Y=N508 S1=Immediate_SE[10] S0=Immediate_SE[7]
+ C=FE_OFN170_n1018 B=n165 A=n164
XU319 AOI2BB1XL $PINS Y=n810 B0=n808 A1N=n809 A0N=FE_OFN127_n288
XU320 AO22X1 $PINS Y=n585 B1=n297 B0=N383 A1=n298 A0=N191
XU321 AOI2BB1XL $PINS Y=n873 B0=n236 A1N=n872 A0N=FE_OFN126_n288
XU322 AOI2BB2XL $PINS Y=n389 B1=n378 B0=n982 A1N=n377 A0N=n995
XU323 INVXL $PINS Y=n377 A=n140
XU324 AOI2BB1XL $PINS Y=n984 B0=n256 A1N=n979 A0N=n1000
XU325 AOI2BB1XL $PINS Y=n967 B0=n258 A1N=n966 A0N=n1000
XU326 OA22XL $PINS Y=n477 B1=n256 B0=n186 A1=n257 A0=n198
XU327 OA22XL $PINS Y=n474 B1=n725 B0=n130 A1=n727 A0=n158
XU328 OA22XL $PINS Y=n475 B1=n728 B0=n157 A1=n258 A0=n220
XU329 OA22XL $PINS Y=n472 B1=n621 B0=n177 A1=n724 A0=n139
XU330 OA22XL $PINS Y=n576 B1=n258 B0=n232 A1=n248 A0=n256
XU331 NOR2X1 $PINS Y=n353 B=n309 A=n311
XU332 NAND2X1 $PINS Y=n215 B=n353 A=n349
XU333 NAND2X1 $PINS Y=n232 B=n353 A=n350
XU334 AOI2BB1XL $PINS Y=n452 B0=n724 A1N=n450 A0N=n288
XU335 AOI2BB1XL $PINS Y=n418 B0=n725 A1N=n417 A0N=n1000
XU336 AOI2BB1XL $PINS Y=n387 B0=n728 A1N=n386 A0N=n1000
XU337 NAND2XL $PINS Y=n975 B=n256 A=n149
XU338 NAND2XL $PINS Y=n962 B=n258 A=n296
XU339 NAND2XL $PINS Y=n778 B=n781 A=n296
XU340 NAND2XL $PINS Y=n374 B=n728 A=n296
XU341 NAND2XL $PINS Y=n469 B=n621 A=n296
XU342 NAND2XL $PINS Y=n432 B=n724 A=n296
XU343 NAND2XL $PINS Y=n765 B=n768 A=n296
XU344 NAND2XL $PINS Y=n412 B=n725 A=n296
XU345 NAND2XL $PINS Y=n1010 B=n1018 A=n161
XU346 NAND2X1 $PINS Y=n198 B=n358 A=n348
XU347 NAND2X1 $PINS Y=n157 B=n359 A=n351
XU348 NAND2X1 $PINS Y=n158 B=n358 A=n354
XU349 NOR3BXL $PINS Y=n1004 C=n1001 B=n1002 AN=n1003
XU350 NOR3BXL $PINS Y=n390 C=n387 B=n388 AN=n389
XU351 AOI22X1 $PINS Y=n110 B1=n286 B0=N219 A1=n287 A0=N347
XU352 AOI22X1 $PINS Y=n111 B1=n286 B0=N218 A1=n287 A0=N346
XU353 AOI22X1 $PINS Y=n112 B1=n286 B0=N215 A1=n287 A0=N343
XU354 AOI22X1 $PINS Y=n113 B1=n152 B0=N204 A1=n287 A0=N332
XU355 AOI22X1 $PINS Y=n114 B1=n286 B0=N214 A1=n287 A0=N342
XU356 AOI22X1 $PINS Y=n115 B1=n152 B0=N216 A1=n287 A0=N344
XU357 AOI22X1 $PINS Y=n116 B1=n152 B0=N211 A1=n287 A0=N339
XU358 AOI22X1 $PINS Y=n117 B1=n152 B0=N212 A1=n287 A0=N340
XU359 AOI22X1 $PINS Y=n118 B1=n152 B0=N210 A1=n287 A0=N338
XU360 INVXL $PINS Y=n398 A=n156
XU361 MXI2XL $PINS Y=n216 S0=n307 B=n271 A=ALUData2[15]
XU362 MXI2XL $PINS Y=n213 S0=Immediate_SE[6] B=n261 A=n262
XU363 MXI2XL $PINS Y=n221 S0=Immediate_SE[6] B=n270 A=n271
XU364 MXI2XL $PINS Y=n210 S0=Immediate_SE[6] B=n267 A=n270
XU365 MXI2XL $PINS Y=n208 S0=Immediate_SE[6] B=n263 A=n264
XU366 MXI2XL $PINS Y=n218 S0=FE_OFN205_n249 B=n264 A=n265
XU367 MXI2XL $PINS Y=n212 S0=Immediate_SE[6] B=n265 A=n266
XU368 MXI2XL $PINS Y=n227 S0=FE_OFN205_n249 B=ALUData2[9] A=ALUData2[8]
XU369 MXI2XL $PINS Y=n223 S0=FE_OFN205_n249 B=n266 A=n267
XU370 MXI2XL $PINS Y=n209 S0=Immediate_SE[6] B=n259 A=n260
XU371 MXI2XL $PINS Y=n219 S0=Immediate_SE[6] B=n260 A=n261
XU372 MXI2XL $PINS Y=n207 S0=Immediate_SE[6] B=n252 A=n253
XU373 MXI2XL $PINS Y=n217 S0=n307 B=n253 A=n254
XU374 MXI2XL $PINS Y=n211 S0=Immediate_SE[6] B=n254 A=n255
XU375 MXI2XL $PINS Y=n222 S0=FE_OFN205_n249 B=n255 A=n259
XU376 MXI2XL $PINS Y=n225 S0=FE_OFN205_n249 B=n262 A=n263
XU377 MXI2XL $PINS Y=n224 S0=FE_OFN205_n249 B=n251 A=n252
XU378 INVX1 $PINS Y=n727 A=n259
XU379 INVX1 $PINS Y=n620 A=n263
XU380 INVX1 $PINS Y=n624 A=n264
XU381 AOI22X1 $PINS Y=n121 B1=n152 B0=N207 A1=n287 A0=N335
XU382 AOI22X1 $PINS Y=n122 B1=n286 B0=N206 A1=n151 A0=N334
XU383 INVX1 $PINS Y=n623 A=n265
XU384 MXI2XL $PINS Y=n174 S0=FE_OFN210_n245 B=n251 A=n243
XU385 INVX1 $PINS Y=n582 A=n266
XU386 AO22XL $PINS Y=n415 B1=n1113 B0=n255 A1=n981 A0=n259
XU387 MXI4X1 $PINS Y=n127 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n216 B=n213
+ A=n228
XU388 MXI3XL $PINS Y=n170 S1=n245 S0=Immediate_SE[8] C=n251 B=n10 A=n240
XU389 INVX1 $PINS Y=n240 A=n176
XU390 AO22XL $PINS Y=n502 B1=n730 B0=n255 A1=n731 A0=n259
XU391 AO22XL $PINS Y=n529 B1=n1115 B0=n255 A1=n730 A0=n259
XU392 AO22XL $PINS Y=n504 B1=n1111 B0=n260 A1=n1113 A0=n261
XU393 MXI3XL $PINS Y=n203 S1=n315 S0=FE_OFN205_n249 C=n204 B=n234 A=n921
XU394 AO22XL $PINS Y=n732 B1=n262 B0=n1112 A1=n263 A0=n1115
XU395 AO22XL $PINS Y=n735 B1=n981 B0=n270 A1=n1114 A0=n271
XU396 AND2XL $PINS Y=n154 B=n251 A=n376
XU397 NOR3X1 $PINS Y=n349 C=n316 B=n307 A=n317
XU398 NOR3X1 $PINS Y=n350 C=n308 B=n317 A=n316
XU399 NOR2X1 $PINS Y=n348 B=n314 A=n310
XU400 NOR2X1 $PINS Y=n354 B=n311 A=n310
XU401 NOR2X1 $PINS Y=n351 B=n309 A=n314
XU402 INVXL $PINS Y=n507 A=ALUData1[22]
XU403 INVXL $PINS Y=n478 A=ALUData1[23]
XU404 INVXL $PINS Y=n385 A=ALUData1[27]
XU405 INVXL $PINS Y=n977 A=ALUData1[29]
XU406 INVXL $PINS Y=n400 A=ALUData1[26]
XU407 INVXL $PINS Y=n996 A=ALUData1[30]
XU408 INVXL $PINS Y=n1015 A=ALUData1[31]
XU409 INVXL $PINS Y=n737 A=ALUData1[16]
XU410 INVX1 $PINS Y=n964 A=ALUData1[28]
XU411 INVXL $PINS Y=n942 A=ALUData1[0]
XU412 AOI2BB1XL $PINS Y=n471 B0=n288 A1N=n294 A0N=n262
XU413 AOI2BB1XL $PINS Y=n498 B0=n288 A1N=n294 A0N=n263
XU414 AOI2BB1XL $PINS Y=n436 B0=n288 A1N=n291 A0N=n261
XU415 AOI2BB1XL $PINS Y=n526 B0=n288 A1N=n294 A0N=n264
XU416 AOI2BB1XL $PINS Y=n413 B0=n288 A1N=n291 A0N=n260
XU417 AOI2BB1XL $PINS Y=n723 B0=FE_OFN126_n288 A1N=n291 A0N=n271
XU418 AOI2BB1XL $PINS Y=n397 B0=n288 A1N=n294 A0N=n259
XU419 AOI2BB1XL $PINS Y=n556 B0=n288 A1N=n294 A0N=n265
XU420 AOI2BB1XL $PINS Y=n594 B0=FE_OFN126_n288 A1N=n294 A0N=n267
XU421 AOI2BB1XL $PINS Y=n573 B0=FE_OFN126_n288 A1N=n294 A0N=n266
XU422 AOI2BB1XL $PINS Y=n994 B0=n288 A1N=n291 A0N=n252
XU423 AOI2BB1XL $PINS Y=n619 B0=FE_OFN126_n288 A1N=n294 A0N=n270
XU424 AOI2BB1XL $PINS Y=n375 B0=n288 A1N=n291 A0N=n255
XU425 AOI2BB1XL $PINS Y=n963 B0=n288 A1N=n992 A0N=n254
XU426 AOI2BB1XL $PINS Y=n976 B0=n288 A1N=n291 A0N=n253
XU427 INVXL $PINS Y=n738 A=n271
XU428 AOI2BB1XL $PINS Y=n1011 B0=n1020 A1N=n1009 A0N=n251
XU429 INVX1 $PINS Y=n606 A=n267
XU430 INVXL $PINS Y=n677 A=n270
XU431 INVX1 $PINS Y=n311 A=n314
XU432 AO22XL $PINS Y=n627 B1=n251 B0=n312 A1=n252 A0=n313
XU433 AND3XL $PINS Y=n983 C=n981 B=n252 A=n982
XU434 INVX1 $PINS Y=n315 A=n316
XU435 NAND2X1 $PINS Y=n451 B=n332 A=n549
XU436 NAND2BX1 $PINS Y=n355 B=n347 AN=ForwardB[0]
XU437 AOI2BB2XL $PINS Y=n748 B1=FE_OFN174_n789 B0=Immediate_SE[15]
+ A1N=FE_OFN173_n283 A0N=n1156
XU438 OA22XL $PINS Y=n854 B1=n279 B0=n1103 A1=FE_OFN171_n281 A0=n1068
XU439 AOI2BB2XL $PINS Y=n750 B1=FE_OFN174_n789 B0=Immediate_SE[14]
+ A1N=FE_OFN173_n283 A0N=n1168
XU440 OA22XL $PINS Y=n841 B1=n279 B0=n1102 A1=FE_OFN171_n281 A0=n1067
XU441 NAND2XL $PINS Y=n591 B=FE_OFN175_n6 A=RData1[18]
XU442 NAND2XL $PINS Y=n466 B=n6 A=RData1[23]
XU443 NAND2XL $PINS Y=n570 B=n6 A=RData1[19]
XU444 NAND2XL $PINS Y=n522 B=n6 A=RData1[21]
XU445 NAND2XL $PINS Y=n615 B=FE_OFN175_n6 A=RData1[17]
XU446 NAND2XL $PINS Y=n749 B=FE_OFN175_n6 A=RData1[14]
XU447 NAND2XL $PINS Y=n394 B=n6 A=RData1[26]
XU448 NAND2XL $PINS Y=n762 B=FE_OFN175_n6 A=RData1[13]
XU449 NAND2XL $PINS Y=n747 B=FE_OFN175_n6 A=RData1[15]
XU450 NAND2XL $PINS Y=n865 B=FE_OFN175_n6 A=RData1[5]
XU451 NAND2XL $PINS Y=n828 B=FE_OFN175_n6 A=RData1[8]
XU452 NAND2XL $PINS Y=n719 B=FE_OFN175_n6 A=RData1[16]
XU453 NAND2XL $PINS Y=n775 B=FE_OFN175_n6 A=RData1[12]
XU454 NAND2XL $PINS Y=n903 B=FE_OFN175_n6 A=RData1[2]
XU455 NAND2XL $PINS Y=n370 B=n6 A=RData1[27]
XU456 NAND2XL $PINS Y=n366 B=n6 A=RData1[29]
XU457 NAND2XL $PINS Y=n365 B=n6 A=RData1[30]
XU458 NAND2XL $PINS Y=n363 B=n6 A=RData1[31]
XU459 NAND2XL $PINS Y=n369 B=n6 A=RData1[28]
XU460 AOI211XL $PINS Y=n445 C0=ID_EX[1] B0=Immediate_SE[4] A1=n1118
+ A0=Immediate_SE[1]
XU461 NAND3XL $PINS Y=n444 C=n445 B=n439 A=Immediate_SE[5]
XU462 AOI2BB1XL $PINS Y=n439 B0=Immediate_SE[3] A1N=n1120 A0N=Immediate_SE[2]
XU463 OAI211XL $PINS Y=n429 C0=n433 B0=n1116 A1=n431 A0=Immediate_SE[5]
XU464 AOI211XL $PINS Y=n431 C0=Immediate_SE[2] B0=Immediate_SE[3] A1=n1120
+ A0=Immediate_SE[1]
XU465 INVXL $PINS Y=n1117 A=Immediate_SE[3]
XU466 INVXL $PINS Y=n1116 A=Immediate_SE[4]
XU467 INVX1 $PINS Y=n1095 A=RData2[14]
XU468 INVX1 $PINS Y=n1093 A=RData2[16]
XU469 AO21XL $PINS Y=n435 B0=n1119 A1=Immediate_SE[5] A0=Immediate_SE[0]
XU470 OA22XL $PINS Y=n1038 B1=n1037 B0=n332 A1=n710 A0=FE_OFN131_n302
XU471 OAI2BB1XL $PINS Y=n1076 B0=n128 A1N=n321 A0N=RegisterRd[1]
XU472 AOI22XL $PINS Y=n128 B1=n163 B0=ID_RegisterRd[1] A1=n162
+ A0=ID_RegisterRt[1]
XU473 OAI2BB1XL $PINS Y=n1073 B0=n131 A1N=RegisterRd[4] A0N=n319
XU474 AOI22XL $PINS Y=n131 B1=n163 B0=ID_RegisterRd[4] A1=n162
+ A0=ID_RegisterRt[4]
XU475 AO21XL $PINS Y=n1074 B0=n1032 A1=n319 A0=RegisterRd[3]
XU476 AO22XL $PINS Y=n1032 B1=n163 B0=ID_RegisterRd[3] A1=n162
+ A0=ID_RegisterRt[3]
XU477 OAI2BB1XL $PINS Y=n1077 B0=n132 A1N=RegisterRd[0] A0N=n319
XU478 AOI22XL $PINS Y=n132 B1=n163 B0=ID_RegisterRd[0] A1=n162
+ A0=ID_RegisterRt[0]
XU479 OAI2BB1XL $PINS Y=n1075 B0=n133 A1N=RegisterRd[2] A0N=n319
XU480 AOI22XL $PINS Y=n133 B1=n163 B0=ID_RegisterRd[2] A1=n162
+ A0=ID_RegisterRt[2]
XU481 XNOR2XL $PINS Y=n549 B=ForwardB[1] A=ForwardB[0]
XU482 NAND3BXL $PINS Y=n453 C=ForwardB[0] B=FE_OFN135_n332 AN=ForwardB[1]
XU483 NAND3BXL $PINS Y=n455 C=FE_OFN135_n332 B=ForwardB[1] AN=ForwardB[0]
XU484 OAI221X4 $PINS Y=n134 C0=n790 B1=n280 B0=n1098 A1=FE_OFN172_n281 A0=n1063
XU485 AOI2BB2XL $PINS Y=n790 B1=FE_OFN174_n789 B0=Immediate_SE[11]
+ A1N=FE_OFN173_n283 A0N=n1165
XU488 CLKBUFX3 $PINS Y=n288 A=n991
XU491 CLKINVX1 $PINS Y=n293 A=n291
XU493 CLKBUFX3 $PINS Y=n294 A=n291
XU496 NAND2X1 $PINS Y=n541 B=FE_OFN135_n332 A=n376
XU497 CLKINVX1 $PINS Y=n991 A=n537
XU498 NOR2X1 $PINS Y=n129 B=n1111 A=n140
XU499 NOR2X1 $PINS Y=n268 B=n1110 A=n295
XU500 NOR2X1 $PINS Y=n156 B=n730 A=n168
XU501 CLKBUFX3 $PINS Y=n291 A=n992
XU503 CLKINVX1 $PINS Y=n597 A=n731
XU504 CLKINVX1 $PINS Y=n622 A=n1111
XU505 CLKINVX1 $PINS Y=n1114 A=n177
XU506 CLKINVX1 $PINS Y=n596 A=n1115
XU507 INVX3 $PINS Y=n321 A=FE_OFN135_n332
XU508 INVX3 $PINS Y=n320 A=FE_OFN135_n332
XU509 CLKINVX1 $PINS Y=n575 A=n1112
XU510 CLKINVX1 $PINS Y=n574 A=n625
XU511 CLKINVX1 $PINS Y=n595 A=n295
XU512 CLKINVX1 $PINS Y=n319 A=FE_OFN135_n332
XU513 MXI2X1 $PINS Y=n183 S0=Immediate_SE[8] B=n136 A=n147
XU514 MXI2X1 $PINS Y=n164 S0=n311 B=n9 A=n239
XU515 CLKINVX1 $PINS Y=n239 A=n180
XU516 AO22X1 $PINS Y=n465 B1=n286 B0=N228 A1=n151 A0=N356
XU517 AO22X1 $PINS Y=n425 B1=n286 B0=N229 A1=n151 A0=N357
XU518 AO22X1 $PINS Y=n408 B1=n286 B0=N230 A1=n151 A0=N358
XU519 AO22X1 $PINS Y=n393 B1=n286 B0=N231 A1=n151 A0=N359
XU520 AO22X1 $PINS Y=n551 B1=n286 B0=N225 A1=n151 A0=N353
XU521 AO22X1 $PINS Y=n492 B1=n286 B0=N227 A1=n151 A0=N355
XU522 AO22X1 $PINS Y=n569 B1=n286 B0=N224 A1=n151 A0=N352
XU523 AO22X1 $PINS Y=n590 B1=n286 B0=N223 A1=n287 A0=N351
XU524 AO22X1 $PINS Y=n520 B1=n286 B0=N226 A1=n151 A0=N354
XU525 AO22X1 $PINS Y=n614 B1=n286 B0=N222 A1=n287 A0=N350
XU526 CLKBUFX3 $PINS Y=n275 A=n931
XU528 MXI2X1 $PINS Y=n182 S0=Immediate_SE[8] B=n145 A=n146
XU529 NAND2X1 $PINS Y=n106 B=n130 A=n129
XU530 CLKINVX1 $PINS Y=n241 A=n172
XU531 NAND2BX1 $PINS Y=n168 B=n186 AN=n185
XU532 NAND2X1 $PINS Y=n140 B=n157 A=n156
XU533 NAND2BX1 $PINS Y=n214 B=n232 AN=n231
XU534 NAND2BX1 $PINS Y=n197 B=n215 AN=n214
XU535 NAND2BX1 $PINS Y=n185 B=n198 AN=n197
XU536 NAND2BX1 $PINS Y=n231 B=n248 AN=n247
XU537 NAND2X1 $PINS Y=n312 B=n331 A=n330
XU538 NAND2X1 $PINS Y=n247 B=n269 A=n268
XU545 CLKBUFX3 $PINS Y=n332 A=n337
XU546 CLKBUFX3 $PINS Y=n298 A=n148
XU547 CLKBUFX3 $PINS Y=n297 A=n150
XU550 CLKBUFX3 $PINS Y=n296 A=n149
XU551 CLKBUFX3 $PINS Y=n287 A=n151
XU552 CLKBUFX3 $PINS Y=n286 A=n152
XU553 NAND2X1 $PINS Y=n177 B=n353 A=n359
XU554 CLKINVX1 $PINS Y=n1113 A=n130
XU555 CLKINVX1 $PINS Y=n731 A=n157
XU556 CLKINVX1 $PINS Y=n730 A=n220
XU558 CLKINVX1 $PINS Y=n1111 A=n158
XU559 CLKINVX1 $PINS Y=n626 A=n232
XU560 CLKINVX1 $PINS Y=n625 A=n215
XU561 CLKINVX1 $PINS Y=n1112 A=n198
XU562 CLKINVX1 $PINS Y=n1115 A=n186
XU563 CLKINVX1 $PINS Y=n981 A=n139
XU564 CLKBUFX3 $PINS Y=n245 A=n317
XU565 CLKBUFX3 $PINS Y=n246 A=n315
XU566 CLKBUFX3 $PINS Y=n249 A=n307
XU568 CLKINVX1 $PINS Y=n1109 A=n248
XU569 CLKINVX1 $PINS Y=n1108 A=n269
XU570 CLKBUFX3 $PINS Y=n341 A=n339
XU576 NAND2X1 $PINS Y=n933 B=n355 A=n352
XU577 CLKINVX1 $PINS Y=n357 A=n355
XU578 CLKINVX1 $PINS Y=n352 A=n356
XU579 NAND2X1 $PINS Y=n935 B=n355 A=n356
XU580 AOI211X1 $PINS Y=n958 C0=n956 B0=n957 A1=FE_OFN132_n284 A0=N508
XU581 AOI2BB1X1 $PINS Y=n956 B0=n954 A1N=n955 A0N=FE_OFN127_n288
XU582 AOI211X1 $PINS Y=n759 C0=n757 B0=n758 A1=FE_OFN132_n284 A0=N507
XU583 AOI2BB1X1 $PINS Y=n757 B0=n755 A1N=n756 A0N=FE_OFN127_n288
XU584 MXI2X1 $PINS Y=N507 S0=Immediate_SE[7] B=n170 A=n169
XU585 AO22X1 $PINS Y=n758 B1=n297 B0=N378 A1=n298 A0=N186
XU586 AOI211X1 $PINS Y=n772 C0=n770 B0=n771 A1=FE_OFN132_n284 A0=N506
XU587 AOI2BB1X1 $PINS Y=n770 B0=n768 A1N=n769 A0N=FE_OFN127_n288
XU588 AOI211X1 $PINS Y=n785 C0=n783 B0=n784 A1=FE_OFN132_n284 A0=N505
XU589 AOI2BB1X1 $PINS Y=n783 B0=n781 A1N=n782 A0N=FE_OFN127_n288
XU590 AO22X1 $PINS Y=n784 B1=n297 B0=N376 A1=n298 A0=N184
XU591 AOI211X1 $PINS Y=n799 C0=n797 B0=n798 A1=FE_OFN132_n284 A0=N504
XU592 AOI2BB1X1 $PINS Y=n797 B0=n795 A1N=n796 A0N=FE_OFN127_n288
XU593 MXI2X1 $PINS Y=N504 S0=Immediate_SE[7] B=n173 A=n181
XU594 AO22X1 $PINS Y=n798 B1=n297 B0=N375 A1=n298 A0=N183
XU595 AOI211X1 $PINS Y=n812 C0=n810 B0=n811 A1=FE_OFN132_n284 A0=N503
XU596 MXI2X1 $PINS Y=N503 S0=Immediate_SE[7] B=n178 A=n182
XU597 AO22X1 $PINS Y=n811 B1=n297 B0=N374 A1=n298 A0=N182
XU598 AOI211X1 $PINS Y=n825 C0=n823 B0=n824 A1=FE_OFN132_n284 A0=N502
XU599 AO22X1 $PINS Y=n824 B1=n297 B0=N373 A1=n298 A0=N181
XU600 AOI211X1 $PINS Y=n837 C0=n835 B0=n836 A1=FE_OFN132_n284 A0=N501
XU601 AO22X1 $PINS Y=n836 B1=n150 B0=N372 A1=n298 A0=N180
XU602 AOI211X1 $PINS Y=n850 C0=n848 B0=n849 A1=FE_OFN132_n284 A0=N500
XU603 MXI2X1 $PINS Y=N500 S0=Immediate_SE[7] B=n183 A=n187
XU604 AOI211X1 $PINS Y=n862 C0=n860 B0=n861 A1=FE_OFN132_n284 A0=N499
XU605 AO22X1 $PINS Y=n861 B1=n150 B0=N370 A1=n148 A0=N178
XU606 AOI211X1 $PINS Y=n875 C0=n873 B0=n874 A1=FE_OFN132_n284 A0=N498
XU607 AO22X1 $PINS Y=n874 B1=n297 B0=N369 A1=n148 A0=N177
XU608 AOI211X1 $PINS Y=n912 C0=n910 B0=n911 A1=FE_OFN132_n284 A0=N495
XU609 AO22X1 $PINS Y=n911 B1=n150 B0=N366 A1=n148 A0=N174
XU610 AOI211X1 $PINS Y=n925 C0=n923 B0=n924 A1=FE_OFN132_n284 A0=N494
XU611 AOI2BB1X1 $PINS Y=n923 B0=n921 A1N=n922 A0N=FE_OFN126_n288
XU612 MXI2X1 $PINS Y=N494 S0=Immediate_SE[7] B=n199 A=n205
XU613 AO22X1 $PINS Y=n924 B1=n150 B0=N365 A1=n148 A0=N173
XU614 AOI211X1 $PINS Y=n887 C0=n885 B0=n886 A1=FE_OFN132_n284 A0=N497
XU615 AO22X1 $PINS Y=n886 B1=n150 B0=N368 A1=n148 A0=N176
XU616 AOI211X1 $PINS Y=n900 C0=n898 B0=n899 A1=FE_OFN132_n284 A0=N496
XU617 AO22X1 $PINS Y=n899 B1=n150 B0=N367 A1=n148 A0=N175
XU618 CLKMX2X2 $PINS Y=n180 S0=n246 B=n213 A=n216
XU619 AOI211X1 $PINS Y=n1023 C0=n1021 B0=n1022 A1=n159 A0=N395
XU620 MXI2X1 $PINS Y=n178 S0=Immediate_SE[8] B=n175 A=n137
XU621 MXI2X1 $PINS Y=n175 S0=n245 B=FE_OFN170_n1018 A=n176
XU622 MXI2X1 $PINS Y=n181 S0=Immediate_SE[8] B=n179 A=n138
XU623 MXI2X1 $PINS Y=n179 S0=n317 B=FE_OFN170_n1018 A=n180
XU624 MXI2X1 $PINS Y=n173 S0=Immediate_SE[8] B=n171 A=n136
XU625 MXI2X1 $PINS Y=n171 S0=FE_OFN210_n245 B=FE_OFN170_n1018 A=n172
XU626 MXI2X1 $PINS Y=n187 S0=Immediate_SE[8] B=n138 A=n127
XU627 MXI2X1 $PINS Y=n191 S0=Immediate_SE[8] B=n147 A=n125
XU628 MXI2X1 $PINS Y=n230 S0=n245 B=n10 A=n192
XU629 MXI3X1 $PINS Y=n199 S1=Immediate_SE[8] S0=n245 C=n127 B=n9 A=n195
XU630 MXI3X1 $PINS Y=n195 S1=n246 S0=FE_OFN205_n249 C=n196 B=n235 A=n896
XU631 MXI3X1 $PINS Y=n202 S1=Immediate_SE[8] S0=Immediate_SE[10] C=n126 B=n242
+ A=n200
XU632 CLKINVX1 $PINS Y=n242 A=n167
XU633 MXI3X1 $PINS Y=n200 S1=Immediate_SE[9] S0=FE_OFN205_n249 C=n201 B=n896
+ A=n234
XU634 MXI4X1 $PINS Y=n136 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n208 B=n207
+ A=n190
XU635 MXI4X1 $PINS Y=n137 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n218 B=n217
+ A=n193
XU636 MXI4X1 $PINS Y=n138 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n212 B=n211
+ A=n196
XU637 AO22X1 $PINS Y=n388 B1=n150 B0=N391 A1=n148 A0=N199
XU638 AO22X1 $PINS Y=n1002 B1=n297 B0=N394 A1=n298 A0=N202
XU639 AO22X1 $PINS Y=n609 B1=n297 B0=N382 A1=n298 A0=N190
XU640 AO22X1 $PINS Y=n741 B1=n297 B0=N380 A1=n298 A0=N188
XU641 AO22X1 $PINS Y=n564 B1=n297 B0=N384 A1=n298 A0=N192
XU642 AO22X1 $PINS Y=n713 B1=n297 B0=N381 A1=n298 A0=N189
XU643 AO22X1 $PINS Y=n968 B1=n150 B0=N392 A1=n148 A0=N200
XU644 AO22X1 $PINS Y=n459 B1=n297 B0=N388 A1=n298 A0=N196
XU645 AO22X1 $PINS Y=n985 B1=n150 B0=N393 A1=n148 A0=N201
XU646 AO22X1 $PINS Y=n421 B1=n297 B0=N389 A1=n298 A0=N197
XU647 AO22X1 $PINS Y=n1007 B1=n152 B0=N234 A1=n287 A0=N362
XU648 AO22X1 $PINS Y=n973 B1=n286 B0=N232 A1=n151 A0=N360
XU649 AO22X1 $PINS Y=n989 B1=n286 B0=N233 A1=n151 A0=N361
XU650 AO22X1 $PINS Y=n1025 B1=n1008 B0=N235 A1=n160 A0=N363
XU651 AO22X1 $PINS Y=n746 B1=n286 B0=N220 A1=n287 A0=N348
XU652 AO22X1 $PINS Y=n718 B1=n286 B0=N221 A1=n151 A0=N349
XU655 NAND2X1 $PINS Y=n995 B=FE_OFN135_n332 A=n154
XU656 OAI222XL $PINS Y=n528 C1=n258 C0=n198 B1=n257 B0=n232 A1=n256 A0=n215
XU657 OAI222XL $PINS Y=n501 C1=n258 C0=n186 B1=n257 B0=n215 A1=n256 A0=n198
XU658 OAI222XL $PINS Y=n577 C1=n622 C0=n620 B1=n220 B0=n724 A1=n597 A0=n621
XU659 OAI222XL $PINS Y=n969 C1=n256 C0=n139 B1=FE_OFN170_n1018 B0=n129 A1=n257
+ A0=n130
XU660 CLKMX2X2 $PINS Y=n176 S0=n246 B=n219 A=n221
XU661 OAI221XL $PINS Y=n546 C0=n540 B1=n541 B0=n543 A1=n544 A0=n995
XU662 AO21X1 $PINS Y=n540 B0=n624 A1=n537 A0=n538
XU663 NOR4X1 $PINS Y=n543 D=n528 C=n529 B=n531 A=n532
XU664 OAI221XL $PINS Y=n514 C0=n510 B1=n541 B0=n511 A1=n513 A0=n995
XU665 AO21X1 $PINS Y=n510 B0=n620 A1=n537 A0=n508
XU666 NOR4X1 $PINS Y=n511 D=n501 C=n502 B=n504 A=n505
XU667 OAI221XL $PINS Y=n736 C0=n726 B1=n248 B0=n727 A1=n269 A0=n728
XU668 OA22X1 $PINS Y=n726 B1=n724 B0=n215 A1=n725 A0=n232
XU669 MXI2X1 $PINS Y=n169 S0=Immediate_SE[8] B=n166 A=n145
XU670 MXI2X1 $PINS Y=n166 S0=n245 B=FE_OFN170_n1018 A=n167
XU671 CLKMX2X2 $PINS Y=n450 S0=n449 B=n293 A=n997
XU672 CLKMX2X2 $PINS Y=n386 S0=n385 B=n293 A=n997
XU673 CLKMX2X2 $PINS Y=n417 S0=n416 B=n293 A=n997
XU674 AOI2BB1X1 $PINS Y=n945 B0=n943 A1N=n944 A0N=FE_OFN126_n288
XU675 CLKMX2X2 $PINS Y=n944 S0=n942 B=FE_OFN128_n293 A=FE_OFN133_n299
XU676 OR4X1 $PINS Y=n742 D=n143 C=n142 B=n141 A=n736
XU677 OAI22XL $PINS Y=n141 B1=n329 B0=n258 A1=n729 A0=n256
XU678 OAI22XL $PINS Y=n142 B1=n257 B0=n331 A1=n1018 A0=n330
XU679 OR4X1 $PINS Y=n143 D=n732 C=n733 B=n734 A=n735
XU680 NAND4X1 $PINS Y=n486 D=n472 C=n474 B=n475 A=n477
XU681 OAI222XL $PINS Y=n378 C1=n258 C0=n139 B1=n257 B0=n158 A1=n256 A0=n130
XU682 AOI2BB1X1 $PINS Y=n563 B0=n623 A1N=n562 A0N=n288
XU683 CLKMX2X2 $PINS Y=n562 S0=n561 B=n293 A=n997
XU684 AOI2BB1X1 $PINS Y=n584 B0=n582 A1N=n583 A0N=n288
XU685 CLKMX2X2 $PINS Y=n583 S0=n581 B=n293 A=FE_OFN133_n299
XU686 CLKMX2X2 $PINS Y=n966 S0=n964 B=n293 A=n997
XU687 AOI2BB1X1 $PINS Y=n740 B0=n738 A1N=n739 A0N=FE_OFN126_n288
XU688 CLKMX2X2 $PINS Y=n739 S0=n737 B=n293 A=FE_OFN133_n299
XU689 CLKMX2X2 $PINS Y=n979 S0=n977 B=n293 A=n997
XU690 NAND2X1 $PINS Y=n830 B=n833 A=n149
XU691 NAND2X1 $PINS Y=n805 B=n808 A=n149
XU692 NAND2X1 $PINS Y=n818 B=n821 A=n149
XU693 NAND2X1 $PINS Y=n918 B=n921 A=n296
XU694 NAND2X1 $PINS Y=n856 B=n237 A=n149
XU695 NAND2X1 $PINS Y=n843 B=n846 A=n296
XU696 NAND2X1 $PINS Y=n906 B=n234 A=n149
XU697 NAND2X1 $PINS Y=n869 B=n236 A=n149
XU698 NAND2X1 $PINS Y=n893 B=n896 A=n149
XU699 NAND2X1 $PINS Y=n881 B=n235 A=n149
XU700 NAND2X1 $PINS Y=n937 B=n943 A=n149
XU701 NAND2X1 $PINS Y=n396 B=n727 A=n296
XU702 NAND2X1 $PINS Y=n496 B=n620 A=n296
XU703 NAND2X1 $PINS Y=n525 B=n624 A=n296
XU704 NAND2X1 $PINS Y=n555 B=n623 A=n296
XU705 NAND2X1 $PINS Y=n572 B=n582 A=n296
XU706 NAND2X1 $PINS Y=n593 B=n606 A=n296
XU707 NAND2X1 $PINS Y=n618 B=n677 A=n296
XU708 NAND2X1 $PINS Y=n722 B=n738 A=n296
XU709 NAND2X1 $PINS Y=n993 B=n257 A=n149
XU710 MXI4X1 $PINS Y=n144 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n221 B=n219
+ A=n227
XU711 MXI4X1 $PINS Y=n146 S1=n246 S0=n245 D=FE_OFN170_n1018 C=n223 B=n222
+ A=n201
XU712 CLKMX2X2 $PINS Y=n538 S0=n534 B=n294 A=n535
XU713 CLKMX2X2 $PINS Y=n508 S0=n507 B=n291 A=n535
XU714 OR4X1 $PINS Y=n586 D=n577 C=n578 B=n579 A=n580
XU715 OAI222XL $PINS Y=n578 C1=n177 C0=n582 B1=n130 B0=n624 A1=n623 A0=n139
XU716 OAI222XL $PINS Y=n580 C1=n596 C0=n725 B1=n574 B0=n728 A1=n575 A0=n727
XU717 OAI221XL $PINS Y=n579 C0=n576 B1=n269 B0=n257 A1=FE_OFN170_n1018 A0=n268
XU718 CLKMX2X2 $PINS Y=n172 S0=n246 B=n209 A=n210
XU719 CLKMX2X2 $PINS Y=n167 S0=n246 B=n222 A=n223
XU720 CLKMX2X2 $PINS Y=n769 S0=n767 B=FE_OFN128_n293 A=FE_OFN133_n299
XU721 CLKMX2X2 $PINS Y=n796 S0=n794 B=FE_OFN128_n293 A=FE_OFN133_n299
XU722 CLKMX2X2 $PINS Y=n822 S0=n820 B=FE_OFN128_n293 A=FE_OFN133_n299
XU723 CLKMX2X2 $PINS Y=n897 S0=n895 B=FE_OFN128_n293 A=FE_OFN133_n299
XU724 AOI2BB1X1 $PINS Y=n712 B0=n677 A1N=n678 A0N=FE_OFN126_n288
XU725 CLKMX2X2 $PINS Y=n678 S0=n676 B=n293 A=FE_OFN133_n299
XU726 CLKMX2X2 $PINS Y=n756 S0=n754 B=FE_OFN128_n293 A=FE_OFN133_n299
XU727 CLKMX2X2 $PINS Y=n859 S0=n858 B=FE_OFN128_n293 A=FE_OFN133_n299
XU728 AOI2BB1X1 $PINS Y=n402 B0=n727 A1N=n401 A0N=n1000
XU729 CLKMX2X2 $PINS Y=n401 S0=n400 B=n293 A=n997
XU730 AOI2BB1X1 $PINS Y=n608 B0=n606 A1N=n607 A0N=n288
XU731 CLKMX2X2 $PINS Y=n607 S0=n605 B=n293 A=FE_OFN133_n299
XU732 AOI2BB1X1 $PINS Y=n1001 B0=n257 A1N=n999 A0N=n1000
XU733 CLKMX2X2 $PINS Y=n999 S0=n996 B=n293 A=n997
XU734 CLKMX2X2 $PINS Y=n884 S0=n883 B=FE_OFN128_n293 A=FE_OFN133_n299
XU735 CLKMX2X2 $PINS Y=n955 S0=n953 B=FE_OFN128_n293 A=FE_OFN133_n299
XU736 CLKMX2X2 $PINS Y=n847 S0=n845 B=FE_OFN128_n293 A=FE_OFN133_n299
XU737 CLKMX2X2 $PINS Y=n872 S0=n871 B=FE_OFN128_n293 A=FE_OFN133_n299
XU738 CLKMX2X2 $PINS Y=n922 S0=n920 B=FE_OFN128_n293 A=FE_OFN133_n299
XU739 CLKMX2X2 $PINS Y=n782 S0=n780 B=FE_OFN128_n293 A=FE_OFN133_n299
XU740 CLKMX2X2 $PINS Y=n809 S0=n807 B=FE_OFN128_n293 A=FE_OFN133_n299
XU741 CLKMX2X2 $PINS Y=n834 S0=n832 B=FE_OFN128_n293 A=FE_OFN133_n299
XU742 CLKMX2X2 $PINS Y=n909 S0=n908 B=FE_OFN128_n293 A=FE_OFN133_n299
XU743 AND2X2 $PINS Y=n148 B=FE_OFN135_n332 A=n1012
XU744 AND2X2 $PINS Y=n149 B=FE_OFN135_n332 A=n161
XU745 AND2X2 $PINS Y=n150 B=FE_OFN135_n332 A=n159
XU746 AND2X2 $PINS Y=n151 B=FE_OFN135_n332 A=n160
XU747 AND2X2 $PINS Y=n152 B=FE_OFN135_n332 A=n1008
XU748 NAND2X1 $PINS Y=n383 B=n940 A=n153
XU749 AOI21X1 $PINS Y=n330 B0=n317 A1=n348 A0=n350
XU750 CLKINVX1 $PINS Y=n1020 A=n382
XU751 NAND2X1 $PINS Y=n248 B=n354 A=n349
XU752 AND2X2 $PINS Y=n1000 B=FE_OFN135_n332 A=n384
XU753 OAI21XL $PINS Y=n384 B0=n382 A1=n177 A0=n383
XU754 NAND2X1 $PINS Y=n269 B=n354 A=n350
XU755 NAND2X1 $PINS Y=n329 B=n351 A=n349
XU756 CLKINVX1 $PINS Y=n1016 A=n1009
XU757 NAND2X1 $PINS Y=n331 B=n349 A=n348
XU758 AND2X2 $PINS Y=n153 B=n1014 A=n155
XU759 AND2X2 $PINS Y=n313 B=n351 A=n350
XU763 NAND2X1 $PINS Y=n139 B=n353 A=n358
XU764 NAND2X1 $PINS Y=n130 B=n354 A=n359
XU765 NAND2X1 $PINS Y=n220 B=n358 A=n351
XU768 CLKBUFX3 $PINS Y=n303 A=n453
XU769 CLKBUFX3 $PINS Y=n302 A=n455
XU773 CLKMX2X2 $PINS Y=n949 S0=n942 B=n937 A=n938
XU774 AOI211X1 $PINS Y=n947 C0=n945 B0=n946 A1=FE_OFN132_n284 A0=N493
XU775 MXI2XL $PINS Y=n226 S0=FE_OFN205_n249 B=ALUData2[15] A=n108
XU776 MXI2XL $PINS Y=n193 S0=FE_OFN205_n249 B=ALUData2[13] A=ALUData2[12]
XU777 MXI2XL $PINS Y=n196 S0=FE_OFN205_n249 B=ALUData2[12] A=n134
XU778 MXI2XL $PINS Y=n201 S0=FE_OFN205_n249 B=n134 A=ALUData2[10]
XU779 MXI2XL $PINS Y=n190 S0=n249 B=n108 A=ALUData2[13]
XU780 NAND2X1 $PINS Y=n1006 B=ALUresult[30] A=n320
XU781 NAND2X1 $PINS Y=n392 B=ALUresult[27] A=n320
XU782 NAND2X1 $PINS Y=n988 B=ALUresult[29] A=n320
XU783 CLKMX2X2 $PINS Y=n987 S0=n977 B=n975 A=n976
XU784 NOR4X1 $PINS Y=n986 D=n983 C=n109 B=n984 A=n985
XU785 NAND2X1 $PINS Y=n589 B=ALUresult[19] A=n321
XU786 AOI211X1 $PINS Y=n587 C0=n584 B0=n585 A1=n586 A0=n982
XU787 NAND2X1 $PINS Y=n463 B=n430 A=n321
XU788 NOR4X1 $PINS Y=n460 D=n452 C=n456 B=n457 A=n459
XU789 NAND2X1 $PINS Y=n424 B=n411 A=n321
XU790 NOR4X1 $PINS Y=n422 D=n418 C=n419 B=n420 A=n421
XU791 NAND2X1 $PINS Y=n490 B=ALUresult[23] A=n321
XU792 AOI211X1 $PINS Y=n487 C0=n483 B0=n484 A1=n486 A0=n982
XU793 NAND2X1 $PINS Y=n960 B=ALUresult[15] A=n320
XU794 CLKMX2X2 $PINS Y=n959 S0=n953 B=n951 A=n952
XU795 NAND2X1 $PINS Y=n761 B=ALUresult[14] A=n321
XU796 CLKMX2X2 $PINS Y=n760 S0=n754 B=n752 A=n753
XU797 NAND2X1 $PINS Y=n774 B=ALUresult[13] A=n321
XU798 CLKMX2X2 $PINS Y=n773 S0=n767 B=n765 A=n766
XU799 NAND2X1 $PINS Y=n787 B=ALUresult[12] A=n321
XU800 CLKMX2X2 $PINS Y=n786 S0=n780 B=n778 A=n779
XU801 NAND2X1 $PINS Y=n801 B=ALUresult[11] A=n320
XU802 CLKMX2X2 $PINS Y=n800 S0=n794 B=n792 A=n793
XU803 NAND2X1 $PINS Y=n814 B=ALUresult[10] A=n321
XU804 CLKMX2X2 $PINS Y=n813 S0=n807 B=n805 A=n806
XU805 NAND2X1 $PINS Y=n827 B=ALUresult[9] A=n321
XU806 CLKMX2X2 $PINS Y=n826 S0=n820 B=n818 A=n819
XU807 NAND2X1 $PINS Y=n839 B=ALUresult[8] A=n320
XU808 CLKMX2X2 $PINS Y=n838 S0=n832 B=n830 A=n831
XU809 NAND2X1 $PINS Y=n852 B=ALUresult[7] A=n321
XU810 CLKMX2X2 $PINS Y=n851 S0=n845 B=n843 A=n844
XU811 NAND2X1 $PINS Y=n864 B=ALUresult[6] A=n320
XU812 CLKMX2X2 $PINS Y=n863 S0=n858 B=n856 A=n857
XU813 NAND2X1 $PINS Y=n877 B=ALUresult[5] A=n320
XU814 CLKMX2X2 $PINS Y=n876 S0=n871 B=n869 A=n870
XU815 NAND2X1 $PINS Y=n889 B=ALUresult[4] A=n320
XU816 CLKMX2X2 $PINS Y=n888 S0=n883 B=n881 A=n882
XU817 NAND2X1 $PINS Y=n902 B=ALUresult[3] A=n320
XU818 CLKMX2X2 $PINS Y=n901 S0=n895 B=n893 A=n894
XU819 NAND2X1 $PINS Y=n914 B=ALUresult[2] A=n320
XU820 CLKMX2X2 $PINS Y=n913 S0=n908 B=n906 A=n907
XU821 NAND4BX1 $PINS Y=next_ALUresult[1] D=n925 C=n926 B=n927 AN=n928
XU822 NAND2X1 $PINS Y=n927 B=ALUresult[1] A=n320
XU823 CLKMX2X2 $PINS Y=n926 S0=n920 B=n918 A=n919
XU824 AO22X1 $PINS Y=n928 B1=n152 B0=N205 A1=n151 A0=N333
XU825 NAND2X1 $PINS Y=n717 B=ALUresult[17] A=n321
XU826 CLKMX2X2 $PINS Y=n716 S0=n676 B=n618 A=n619
XU827 AOI211X1 $PINS Y=n715 C0=n712 B0=n713 A1=n714 A0=n982
XU828 NAND2X1 $PINS Y=n613 B=ALUresult[18] A=n321
XU829 CLKMX2X2 $PINS Y=n612 S0=n605 B=n593 A=n594
XU830 AOI211X1 $PINS Y=n611 C0=n608 B0=n609 A1=n610 A0=FE_OFN132_n284
XU831 NAND2X1 $PINS Y=n568 B=ALUresult[20] A=n321
XU832 AOI211X1 $PINS Y=n566 C0=n563 B0=n564 A1=n565 A0=n982
XU833 NAND2X1 $PINS Y=n745 B=ALUresult[16] A=n321
XU834 CLKMX2X2 $PINS Y=n744 S0=n737 B=n722 A=n723
XU835 AOI211X1 $PINS Y=n743 C0=n740 B0=n741 A1=n742 A0=FE_OFN132_n284
XU836 NAND2X1 $PINS Y=n407 B=ALUresult[26] A=n321
XU837 AOI211X1 $PINS Y=n405 C0=n402 B0=n403 A1=n404 A0=n982
XU838 NAND2X1 $PINS Y=n550 B=ALUresult[21] A=n321
XU839 NAND2X1 $PINS Y=n519 B=ALUresult[22] A=n321
XU840 NAND2X1 $PINS Y=n972 B=ALUresult[28] A=n320
XU841 AOI211X1 $PINS Y=n970 C0=n967 B0=n968 A1=n969 A0=FE_OFN132_n284
XU842 CLKINVX1 $PINS Y=n1063 A=WBData[11]
XU843 MXI2X1 $PINS Y=N493 S0=Immediate_SE[7] B=n202 A=n206
XU844 MX3XL $PINS Y=n206 S1=Immediate_SE[8] S0=Immediate_SE[10] C=n230 B=n176
+ A=n233
XU845 MXI3XL $PINS Y=n233 S1=Immediate_SE[9] S0=Immediate_SE[6] C=n238
+ B=ALUData2[1] A=n5
XU846 CLKINVX1 $PINS Y=n238 A=n227
XU847 MXI3X1 $PINS Y=n205 S1=Immediate_SE[8] S0=Immediate_SE[10] C=n125 B=n241
+ A=n203
XU848 MXI3X1 $PINS Y=n189 S1=n246 S0=n249 C=n190 B=n237 A=n236
XU849 CLKINVX1 $PINS Y=n237 A=ALUData2[6]
XU850 MXI2XL $PINS Y=n228 S0=n249 B=ALUData2[8] A=ALUData2[7]
XU851 MXI2XL $PINS Y=n229 S0=FE_OFN205_n249 B=ALUData2[7] A=ALUData2[6]
XU852 INVXL $PINS Y=n781 A=ALUData2[12]
XU853 INVXL $PINS Y=n833 A=ALUData2[8]
XU854 INVXL $PINS Y=n808 A=ALUData2[10]
XU855 INVXL $PINS Y=n768 A=ALUData2[13]
XU856 INVXL $PINS Y=n795 A=n134
XU857 INVXL $PINS Y=n821 A=ALUData2[9]
XU858 INVXL $PINS Y=n921 A=ALUData2[1]
XU859 INVXL $PINS Y=n954 A=ALUData2[15]
XU860 INVXL $PINS Y=n755 A=ALUData2[14]
XU861 INVXL $PINS Y=n846 A=ALUData2[7]
XU862 INVXL $PINS Y=n943 A=n5
XU863 INVXL $PINS Y=n767 A=ALUData1[13]
XU864 INVXL $PINS Y=n794 A=ALUData1[11]
XU865 INVXL $PINS Y=n820 A=n702
XU866 INVXL $PINS Y=n895 A=ALUData1[3]
XU867 INVXL $PINS Y=n676 A=ALUData1[17]
XU868 INVXL $PINS Y=n449 A=ALUData1[24]
XU869 INVXL $PINS Y=n561 A=ALUData1[20]
XU870 INVXL $PINS Y=n754 A=ALUData1[14]
XU871 INVXL $PINS Y=n858 A=ALUData1[6]
XU872 INVXL $PINS Y=n605 A=ALUData1[18]
XU873 INVXL $PINS Y=n883 A=ALUData1[4]
XU874 INVXL $PINS Y=n581 A=ALUData1[19]
XU875 INVXL $PINS Y=n534 A=ALUData1[21]
XU876 INVXL $PINS Y=n416 A=ALUData1[25]
XU877 INVXL $PINS Y=n953 A=ALUData1[15]
XU878 INVXL $PINS Y=n845 A=ALUData1[7]
XU879 INVXL $PINS Y=n871 A=ALUData1[5]
XU880 INVXL $PINS Y=n920 A=ALUData1[1]
XU881 INVXL $PINS Y=n780 A=ALUData1[12]
XU882 INVXL $PINS Y=n807 A=ALUData1[10]
XU883 INVXL $PINS Y=n832 A=ALUData1[8]
XU884 INVXL $PINS Y=n908 A=ALUData1[2]
XU885 MXI2XL $PINS Y=n204 S0=FE_OFN205_n249 B=ALUData2[10] A=ALUData2[9]
XU886 OAI221XL $PINS Y=n404 C0=n399 B1=n728 B0=n139 A1=n258 A0=n130
XU887 AOI222XL $PINS Y=n399 C1=n731 C0=n252 B1=n398 B0=n251 A1=n1111 A0=n253
XU888 AOI222XL $PINS Y=n559 C1=n255 C0=n1112 B1=n254 B0=n625 A1=n259 A0=n1115
XU889 NOR4X1 $PINS Y=n631 D=n627 C=n628 B=n629 A=n630
XU890 AO22X1 $PINS Y=n630 B1=n625 B0=n260 A1=n261 A0=n1112
XU891 AO22X1 $PINS Y=n629 B1=n1109 B0=n255 A1=n626 A0=n259
XU892 AO22X1 $PINS Y=n628 B1=n1110 B0=n253 A1=n254 A0=n1108
XU893 AOI31X1 $PINS Y=n457 B0=n541 A2=n437 A1=n438 A0=n440
XU894 OA22X1 $PINS Y=n440 B1=n220 B0=n256 A1=n257 A0=n186
XU895 AOI222XL $PINS Y=n437 C1=n981 C0=n260 B1=n259 B0=n1113 A1=n261 A0=n1114
XU896 OA22X1 $PINS Y=n438 B1=n622 B0=n728 A1=n597 A0=n258
XU897 CLKINVX1 $PINS Y=n1055 A=WBData[19]
XU898 CLKINVX1 $PINS Y=n1060 A=WBData[14]
XU899 CLKINVX1 $PINS Y=n1051 A=WBData[23]
XU900 CLKINVX1 $PINS Y=n1058 A=WBData[16]
XU901 CLKINVX1 $PINS Y=n1057 A=WBData[17]
XU902 CLKINVX1 $PINS Y=n1048 A=WBData[26]
XU903 CLKINVX1 $PINS Y=n1050 A=WBData[24]
XU904 CLKINVX1 $PINS Y=n1047 A=WBData[27]
XU905 CLKINVX1 $PINS Y=n1061 A=WBData[13]
XU906 CLKINVX1 $PINS Y=n1056 A=WBData[18]
XU907 CLKINVX1 $PINS Y=n1044 A=WBData[30]
XU908 CLKINVX1 $PINS Y=n1043 A=WBData[31]
XU909 CLKINVX1 $PINS Y=n1053 A=WBData[21]
XU910 CLKINVX1 $PINS Y=n1052 A=WBData[22]
XU911 CLKINVX1 $PINS Y=n1054 A=WBData[20]
XU912 CLKINVX1 $PINS Y=n1039 A=WBData[1]
XU913 CLKINVX1 $PINS Y=n1035 A=WBData[0]
XU914 CLKINVX1 $PINS Y=n1070 A=WBData[4]
XU915 CLKINVX1 $PINS Y=n1065 A=WBData[9]
XU916 AOI2BB1X1 $PINS Y=n420 B0=n541 A1N=n414 A0N=n415
XU917 OAI222XL $PINS Y=n414 C1=n258 C0=n158 B1=n220 B0=n257 A1=n597 A0=n256
XU918 NAND4X1 $PINS Y=n610 D=n601 C=n602 B=n603 A=n604
XU919 AOI222XL $PINS Y=n602 C1=n625 C0=n259 B1=n626 B0=n255 A1=n1112 A0=n260
XU920 OA22X1 $PINS Y=n603 B1=n248 B0=n258 A1=n269 A0=n256
XU921 OA22X1 $PINS Y=n604 B1=n329 B0=n257 A1=n595 A0=FE_OFN170_n1018
XU922 NAND4X1 $PINS Y=n714 D=n631 C=n636 B=n674 A=n675
XU923 AOI222XL $PINS Y=n636 C1=n981 C0=n267 B1=n266 B0=n1113 A1=n270 A0=n1114
XU924 OA22X1 $PINS Y=n674 B1=n622 B0=n623 A1=n624 A0=n157
XU925 OA22X1 $PINS Y=n675 B1=n220 B0=n620 A1=n621 A0=n186
XU926 NAND4X1 $PINS Y=n565 D=n557 C=n558 B=n559 A=n560
XU927 AOI222XL $PINS Y=n560 C1=n252 C0=n1109 B1=n251 B0=n247 A1=n253 A0=n626
XU928 AOI222XL $PINS Y=n557 C1=n981 C0=n264 B1=n263 B0=n1113 A1=n265 A0=n1114
XU929 AOI222XL $PINS Y=n558 C1=n261 C0=n731 B1=n260 B0=n730 A1=n262 A0=n1111
XU930 AOI2BB1XL $PINS Y=n779 B0=FE_OFN127_n288 A1N=n291 A0N=ALUData2[12]
XU931 AOI2BB1XL $PINS Y=n831 B0=FE_OFN127_n288 A1N=n992 A0N=ALUData2[8]
XU932 AOI2BB1XL $PINS Y=n806 B0=FE_OFN127_n288 A1N=n294 A0N=ALUData2[10]
XU933 AOI2BB1XL $PINS Y=n766 B0=FE_OFN127_n288 A1N=n291 A0N=ALUData2[13]
XU934 AOI2BB1XL $PINS Y=n793 B0=FE_OFN127_n288 A1N=n291 A0N=n134
XU935 AOI2BB1XL $PINS Y=n819 B0=FE_OFN127_n288 A1N=n291 A0N=ALUData2[9]
XU936 AOI2BB1XL $PINS Y=n919 B0=FE_OFN126_n288 A1N=n992 A0N=ALUData2[1]
XU937 AOI2BB1XL $PINS Y=n857 B0=FE_OFN126_n288 A1N=n294 A0N=ALUData2[6]
XU938 AOI2BB1XL $PINS Y=n952 B0=FE_OFN127_n288 A1N=n291 A0N=ALUData2[15]
XU939 AOI2BB1XL $PINS Y=n753 B0=FE_OFN127_n288 A1N=n291 A0N=n108
XU940 AOI2BB1XL $PINS Y=n844 B0=FE_OFN127_n288 A1N=n992 A0N=ALUData2[7]
XU941 AOI2BB1XL $PINS Y=n907 B0=FE_OFN126_n288 A1N=n291 A0N=ALUData2[2]
XU942 AOI2BB1XL $PINS Y=n870 B0=FE_OFN127_n288 A1N=n291 A0N=ALUData2[5]
XU943 AOI2BB1XL $PINS Y=n894 B0=FE_OFN126_n288 A1N=n992 A0N=ALUData2[3]
XU944 AOI2BB1XL $PINS Y=n882 B0=FE_OFN127_n288 A1N=n992 A0N=ALUData2[4]
XU945 AOI2BB1XL $PINS Y=n938 B0=FE_OFN126_n288 A1N=n291 A0N=n5
XU946 CLKINVX1 $PINS Y=n243 A=n164
XU947 AO22X1 $PINS Y=n483 B1=n980 B0=n197 A1=n262 A0=n481
XU948 NAND2X1 $PINS Y=n481 B=n537 A=n480
XU949 CLKMX2X2 $PINS Y=n480 S0=n478 B=n294 A=n535
XU950 AO22X1 $PINS Y=n733 B1=n730 B0=n264 A1=n731 A0=n265
XU951 CLKBUFX3 $PINS Y=n258 A=n965
XU952 CLKINVX1 $PINS Y=n965 A=n254
XU953 CLKBUFX3 $PINS Y=n256 A=n978
XU954 CLKINVX1 $PINS Y=n978 A=n253
XU955 AND3X2 $PINS Y=n601 C=n598 B=n599 A=n600
XU956 AOI222XL $PINS Y=n598 C1=n981 C0=n266 B1=n265 B0=n1113 A1=n267 A0=n1114
XU957 OA22X1 $PINS Y=n599 B1=n622 B0=n624 A1=n597 A0=n620
XU958 OA22X1 $PINS Y=n600 B1=n220 B0=n621 A1=n596 A0=n724
XU959 AO22X1 $PINS Y=n734 B1=n266 B0=n1111 A1=n267 A0=n1113
XU960 CLKMX2X2 $PINS Y=n1019 S0=n1015 B=n1016 A=n1017
XU961 AND2X2 $PINS Y=n1017 B=n1013 A=n1014
XU962 AO22X1 $PINS Y=n532 B1=n981 B0=n263 A1=n1114 A0=n264
XU963 AO22X1 $PINS Y=n505 B1=n981 B0=n262 A1=n1114 A0=n263
XU964 NAND3BX1 $PINS Y=n535 C=n1013 B=n1014 AN=n319
XU965 CLKINVX1 $PINS Y=n1014 A=n939
XU966 CLKINVX1 $PINS Y=n1008 A=n373
XU967 NAND2X1 $PINS Y=n434 B=n1119 A=n439
XU968 CLKINVX1 $PINS Y=n337 A=stall
XU969 CLKINVX1 $PINS Y=n1012 A=n379
XU970 CLKBUFX3 $PINS Y=n339 A=rst
XU972 CLKMX2X2 $PINS Y=n948 S0=n320 B=n1149 A=n941
XU973 NAND4X1 $PINS Y=n941 D=n939 C=n940 B=n155 A=N524
XU974 CLKINVX1 $PINS Y=n867 A=Immediate_SE[5]
XU975 OA22X1 $PINS Y=n879 B1=n279 B0=n1105 A1=FE_OFN171_n281 A0=n1070
XU976 OA22X1 $PINS Y=n934 B1=n1036 B0=n279 A1=n1035 A0=FE_OFN171_n281
XU977 NAND2X1 $PINS Y=n788 B=FE_OFN175_n6 A=RData1[11]
XU978 NAND2X1 $PINS Y=n815 B=FE_OFN175_n6 A=RData1[9]
XU979 NAND2X1 $PINS Y=n552 B=n6 A=RData1[20]
XU980 NAND2X1 $PINS Y=n853 B=FE_OFN175_n6 A=RData1[6]
XU981 NAND2X1 $PINS Y=n493 B=FE_OFN175_n6 A=RData1[22]
XU982 NAND2X1 $PINS Y=n840 B=FE_OFN175_n6 A=RData1[7]
XU983 OAI221XL $PINS Y=ALUData2[31] C0=n360 B1=n280 B0=n1078 A1=FE_OFN171_n281
+ A0=n1043
XU984 AOI2BB2X1 $PINS Y=n360 B1=FE_OFN174_n789 B0=Immediate_SE[31] A1N=n283
+ A0N=n679
XU985 NAND2X1 $PINS Y=n409 B=n6 A=RData1[25]
XU986 OAI221XL $PINS Y=ALUData2[26] C0=n395 B1=n280 B0=n1083 A1=FE_OFN171_n281
+ A0=n1048
XU987 AOI2BB2X1 $PINS Y=n395 B1=FE_OFN174_n789 B0=Immediate_SE[26] A1N=n283
+ A0N=n684
XU988 OAI221XL $PINS Y=ALUData2[27] C0=n371 B1=n279 B0=n1082 A1=FE_OFN171_n281
+ A0=n1047
XU989 AOI2BB2X1 $PINS Y=n371 B1=FE_OFN174_n789 B0=Immediate_SE[27] A1N=n283
+ A0N=n683
XU990 CLKBUFX3 $PINS Y=n260 A=ALUData2[25]
XU991 OAI221XL $PINS Y=ALUData2[25] C0=n410 B1=n280 B0=n1084 A1=FE_OFN171_n281
+ A0=n1049
XU992 AOI2BB2X1 $PINS Y=n410 B1=FE_OFN174_n789 B0=Immediate_SE[25]
+ A1N=FE_OFN173_n283 A0N=n685
XU993 OAI221XL $PINS Y=ALUData2[30] C0=n364 B1=n279 B0=n1079 A1=n933 A0=n1044
XU994 AOI2BB2X1 $PINS Y=n364 B1=FE_OFN174_n789 B0=Immediate_SE[30] A1N=n283
+ A0N=n680
XU995 CLKBUFX3 $PINS Y=n261 A=ALUData2[24]
XU996 OAI221XL $PINS Y=ALUData2[24] C0=n427 B1=n280 B0=n1085 A1=FE_OFN171_n281
+ A0=n1050
XU997 AOI2BB2X1 $PINS Y=n427 B1=FE_OFN174_n789 B0=Immediate_SE[24]
+ A1N=FE_OFN173_n283 A0N=n686
XU998 OAI221XL $PINS Y=ALUData2[29] C0=n367 B1=n279 B0=n1080 A1=FE_OFN171_n281
+ A0=n1045
XU999 AOI2BB2X1 $PINS Y=n367 B1=FE_OFN174_n789 B0=Immediate_SE[29] A1N=n283
+ A0N=n681
XU1000 OAI221XL $PINS Y=ALUData2[23] C0=n468 B1=n279 B0=n1086 A1=FE_OFN171_n281
+ A0=n1051
XU1001 AOI2BB2X1 $PINS Y=n468 B1=FE_OFN174_n789 B0=Immediate_SE[23]
+ A1N=FE_OFN173_n283 A0N=n687
XU1002 OAI221XL $PINS Y=ALUData2[22] C0=n495 B1=n279 B0=n1087 A1=FE_OFN171_n281
+ A0=n1052
XU1003 AOI2BB2X1 $PINS Y=n495 B1=FE_OFN174_n789 B0=Immediate_SE[22]
+ A1N=FE_OFN173_n283 A0N=n688
XU1004 OAI221XL $PINS Y=ALUData2[28] C0=n368 B1=n279 B0=n1081 A1=FE_OFN171_n281
+ A0=n1046
XU1005 AOI2BB2X1 $PINS Y=n368 B1=FE_OFN174_n789 B0=Immediate_SE[28] A1N=n283
+ A0N=n682
XU1006 CLKBUFX3 $PINS Y=n265 A=ALUData2[20]
XU1007 OAI221XL $PINS Y=ALUData2[20] C0=n553 B1=n280 B0=n1089 A1=FE_OFN172_n281
+ A0=n1054
XU1008 AOI2BB2X1 $PINS Y=n553 B1=FE_OFN174_n789 B0=Immediate_SE[20]
+ A1N=FE_OFN173_n283 A0N=n690
XU1009 OAI221XL $PINS Y=ALUData2[18] C0=n592 B1=n280 B0=n1091 A1=FE_OFN172_n281
+ A0=n1056
XU1010 AOI2BB2X1 $PINS Y=n592 B1=FE_OFN174_n789 B0=Immediate_SE[18]
+ A1N=FE_OFN173_n283 A0N=n692
XU1011 OAI221XL $PINS Y=ALUData2[19] C0=n571 B1=n280 B0=n1090 A1=FE_OFN172_n281
+ A0=n1055
XU1012 AOI2BB2X1 $PINS Y=n571 B1=FE_OFN174_n789 B0=Immediate_SE[19]
+ A1N=FE_OFN173_n283 A0N=n691
XU1013 OAI221XL $PINS Y=ALUData2[21] C0=n523 B1=n280 B0=n1088 A1=FE_OFN172_n281
+ A0=n1053
XU1014 AOI2BB2X1 $PINS Y=n523 B1=FE_OFN174_n789 B0=Immediate_SE[21]
+ A1N=FE_OFN173_n283 A0N=n689
XU1015 CLKBUFX3 $PINS Y=n270 A=ALUData2[17]
XU1016 OAI221XL $PINS Y=ALUData2[17] C0=n616 B1=n280 B0=n1092 A1=FE_OFN172_n281
+ A0=n1057
XU1017 AOI2BB2X1 $PINS Y=n616 B1=FE_OFN174_n789 B0=Immediate_SE[17]
+ A1N=FE_OFN173_n283 A0N=n693
XU1018 CLKBUFX3 $PINS Y=n271 A=ALUData2[16]
XU1019 OAI221XL $PINS Y=ALUData2[16] C0=n720 B1=n280 B0=n1093 A1=FE_OFN172_n281
+ A0=n1058
XU1020 AOI2BB2X1 $PINS Y=n720 B1=FE_OFN174_n789 B0=Immediate_SE[16]
+ A1N=FE_OFN173_n283 A0N=n694
XU1021 CLKINVX1 $PINS Y=n1098 A=RData2[11]
XU1022 CLKINVX1 $PINS Y=n372 A=ID_EX[2]
XU1023 NAND2X1 $PINS Y=n381 B=ID_EX[2] A=n441
XU1024 NAND4X1 $PINS Y=n441 D=n442 C=n1120 B=n1116 A=n1117
XU1025 NAND2X1 $PINS Y=n939 B=n447 A=n446
XU1026 XOR2X1 $PINS Y=n446 B=ID_EX[1] A=ID_EX[2]
XU1027 OAI21XL $PINS Y=n447 B0=n1042 A1=n372 A0=n448
XU1028 CLKINVX1 $PINS Y=n1042 A=ID_EX[3]
XU1029 NAND4BX1 $PINS Y=n428 D=n1042 C=n429 B=ID_EX[2] AN=ID_EX[1]
XU1030 AOI2BB2X1 $PINS Y=n433 B1=n435 B0=n434 A1N=n1117 A0N=n1118
XU1031 CLKINVX1 $PINS Y=n1081 A=RData2[28]
XU1032 CLKINVX1 $PINS Y=n1090 A=RData2[19]
XU1033 CLKINVX1 $PINS Y=n1092 A=RData2[17]
XU1034 CLKINVX1 $PINS Y=n1091 A=RData2[18]
XU1035 CLKINVX1 $PINS Y=n1082 A=RData2[27]
XU1036 CLKINVX1 $PINS Y=n1083 A=RData2[26]
XU1037 CLKINVX1 $PINS Y=n1086 A=RData2[23]
XU1038 CLKINVX1 $PINS Y=n1084 A=RData2[25]
XU1039 CLKINVX1 $PINS Y=n1085 A=RData2[24]
XU1040 CLKINVX1 $PINS Y=n1087 A=RData2[22]
XU1041 CLKINVX1 $PINS Y=n1088 A=RData2[21]
XU1042 CLKINVX1 $PINS Y=n1089 A=RData2[20]
XU1043 CLKINVX1 $PINS Y=n1078 A=RData2[31]
XU1044 CLKINVX1 $PINS Y=n1080 A=RData2[29]
XU1045 CLKINVX1 $PINS Y=n1079 A=RData2[30]
XU1046 OA21XL $PINS Y=n448 B0=Immediate_SE[5] A1=Immediate_SE[1] A0=n1118
XU1047 OAI221XL $PINS Y=n660 C0=n1038 B1=n1039 B0=n303 A1=n1040
+ A0=FE_OFN129_n306
XU1048 OAI221XL $PINS Y=n668 C0=n1034 B1=n1035 B0=n303 A1=n1036
+ A0=FE_OFN129_n306
XU1049 OA22X1 $PINS Y=n1034 B1=n905 B0=n332 A1=n1149 A0=FE_OFN131_n302
XU1050 OAI221XL $PINS Y=n637 C0=n454 B1=FE_OFN130_n303 B0=n1055 A1=n451
+ A0=n1090
XU1051 AOI2BB2XL $PINS Y=n454 B1=MEMWriteData[19] B0=n320 A1N=n691 A0N=n302
XU1052 OAI221XL $PINS Y=n638 C0=n458 B1=FE_OFN130_n303 B0=n1053 A1=n451
+ A0=n1088
XU1053 AOI2BB2XL $PINS Y=n458 B1=MEMWriteData[21] B0=FE_OFN134_n319 A1N=n689
+ A0N=n302
XU1054 OAI221XL $PINS Y=n639 C0=n461 B1=FE_OFN130_n303 B0=n1052 A1=n451
+ A0=n1087
XU1055 AOI2BB2XL $PINS Y=n461 B1=MEMWriteData[22] B0=n319 A1N=n688 A0N=n302
XU1056 OAI221XL $PINS Y=n640 C0=n464 B1=FE_OFN130_n303 B0=n1051 A1=n451
+ A0=n1086
XU1057 AOI2BB2XL $PINS Y=n464 B1=MEMWriteData[23] B0=FE_OFN134_n319 A1N=n687
+ A0N=n302
XU1058 OAI221XL $PINS Y=n641 C0=n467 B1=FE_OFN130_n303 B0=n1050 A1=n451
+ A0=n1085
XU1059 AOI2BB2XL $PINS Y=n467 B1=MEMWriteData[24] B0=FE_OFN134_n319 A1N=n686
+ A0N=n302
XU1060 OAI221XL $PINS Y=n642 C0=n470 B1=FE_OFN130_n303 B0=n1049 A1=n451
+ A0=n1084
XU1061 AOI2BB2XL $PINS Y=n470 B1=MEMWriteData[25] B0=FE_OFN134_n319 A1N=n685
+ A0N=n302
XU1062 OAI221XL $PINS Y=n643 C0=n473 B1=n303 B0=n1048 A1=n451 A0=n1083
XU1063 AOI2BB2XL $PINS Y=n473 B1=MEMWriteData[26] B0=n319 A1N=n684 A0N=n302
XU1064 OAI221XL $PINS Y=n644 C0=n476 B1=n303 B0=n1047 A1=n451 A0=n1082
XU1065 OA22X1 $PINS Y=n476 B1=n683 B0=n302 A1=n1142 A0=FE_OFN135_n332
XU1066 OAI221XL $PINS Y=n645 C0=n479 B1=n303 B0=n1046 A1=n451 A0=n1081
XU1067 OA22X1 $PINS Y=n479 B1=n682 B0=n302 A1=n1139 A0=n332
XU1068 OAI221XL $PINS Y=n646 C0=n482 B1=FE_OFN130_n303 B0=n1059
+ A1=FE_OFN129_n306 A0=n1094
XU1069 AOI2BB2XL $PINS Y=n482 B1=MEMWriteData[15] B0=FE_OFN134_n319 A1N=n1156
+ A0N=FE_OFN131_n302
XU1070 OAI221XL $PINS Y=n647 C0=n485 B1=FE_OFN130_n303 B0=n1060
+ A1=FE_OFN129_n306 A0=n1095
XU1071 AOI2BB2XL $PINS Y=n485 B1=MEMWriteData[14] B0=FE_OFN134_n319 A1N=n1168
+ A0N=FE_OFN131_n302
XU1072 OAI221XL $PINS Y=n648 C0=n488 B1=FE_OFN130_n303 B0=n1061
+ A1=FE_OFN129_n306 A0=n1096
XU1073 AOI2BB2XL $PINS Y=n488 B1=MEMWriteData[13] B0=FE_OFN134_n319 A1N=n1162
+ A0N=FE_OFN131_n302
XU1074 OAI221XL $PINS Y=n649 C0=n491 B1=FE_OFN130_n303 B0=n1062
+ A1=FE_OFN129_n306 A0=n1097
XU1075 AOI2BB2XL $PINS Y=n491 B1=MEMWriteData[12] B0=FE_OFN134_n319 A1N=n1159
+ A0N=FE_OFN131_n302
XU1076 OAI221XL $PINS Y=n650 C0=n494 B1=FE_OFN130_n303 B0=n1063
+ A1=FE_OFN129_n306 A0=n1098
XU1077 AOI2BB2XL $PINS Y=n494 B1=MEMWriteData[11] B0=FE_OFN134_n319 A1N=n1165
+ A0N=FE_OFN131_n302
XU1078 OAI221XL $PINS Y=n661 C0=n527 B1=FE_OFN130_n303 B0=n1057
+ A1=FE_OFN129_n306 A0=n1092
XU1079 AOI2BB2XL $PINS Y=n527 B1=MEMWriteData[17] B0=FE_OFN134_n319 A1N=n693
+ A0N=FE_OFN131_n302
XU1080 OAI221XL $PINS Y=n662 C0=n530 B1=FE_OFN130_n303 B0=n1056
+ A1=FE_OFN129_n306 A0=n1091
XU1081 AOI2BB2XL $PINS Y=n530 B1=MEMWriteData[18] B0=FE_OFN134_n319 A1N=n692
+ A0N=FE_OFN131_n302
XU1082 OAI221XL $PINS Y=n663 C0=n533 B1=FE_OFN130_n303 B0=n1054
+ A1=FE_OFN129_n306 A0=n1089
XU1083 AOI2BB2XL $PINS Y=n533 B1=MEMWriteData[20] B0=FE_OFN134_n319 A1N=n690
+ A0N=FE_OFN131_n302
XU1084 OAI221XL $PINS Y=n664 C0=n536 B1=n303 B0=n1045 A1=n451 A0=n1080
XU1085 OA22X1 $PINS Y=n536 B1=n681 B0=n302 A1=n1136 A0=n332
XU1086 OAI221XL $PINS Y=n665 C0=n539 B1=FE_OFN130_n303 B0=n1058
+ A1=FE_OFN129_n306 A0=n1093
XU1087 AOI2BB2XL $PINS Y=n539 B1=MEMWriteData[16] B0=FE_OFN134_n319 A1N=n694
+ A0N=FE_OFN131_n302
XU1088 OAI221XL $PINS Y=n666 C0=n542 B1=n303 B0=n1044 A1=n451 A0=n1079
XU1089 OA22X1 $PINS Y=n542 B1=n680 B0=n302 A1=n1133 A0=FE_OFN135_n332
XU1090 OAI221XL $PINS Y=n667 C0=n545 B1=n303 B0=n1043 A1=n451 A0=n1078
XU1091 OA22X1 $PINS Y=n545 B1=n679 B0=n302 A1=n1041 A0=FE_OFN135_n332
XU1092 OAI221XL $PINS Y=n651 C0=n497 B1=FE_OFN130_n303 B0=n1064
+ A1=FE_OFN129_n306 A0=n1099
XU1093 AOI2BB2XL $PINS Y=n497 B1=MEMWriteData[10] B0=FE_OFN134_n319 A1N=n1180
+ A0N=FE_OFN131_n302
XU1094 OAI221XL $PINS Y=n652 C0=n500 B1=FE_OFN130_n303 B0=n1065
+ A1=FE_OFN129_n306 A0=n1100
XU1095 AOI2BB2XL $PINS Y=n500 B1=MEMWriteData[9] B0=FE_OFN134_n319 A1N=n1171
+ A0N=FE_OFN131_n302
XU1096 OAI221XL $PINS Y=n653 C0=n503 B1=FE_OFN130_n303 B0=n1066
+ A1=FE_OFN129_n306 A0=n1101
XU1097 AOI2BB2XL $PINS Y=n503 B1=MEMWriteData[8] B0=FE_OFN134_n319 A1N=n703
+ A0N=FE_OFN131_n302
XU1098 OAI221XL $PINS Y=n654 C0=n506 B1=FE_OFN130_n303 B0=n1067
+ A1=FE_OFN129_n306 A0=n1102
XU1099 AOI2BB2XL $PINS Y=n506 B1=MEMWriteData[7] B0=FE_OFN134_n319 A1N=n1174
+ A0N=FE_OFN131_n302
XU1100 OAI221XL $PINS Y=n655 C0=n509 B1=FE_OFN130_n303 B0=n1068
+ A1=FE_OFN129_n306 A0=n1103
XU1101 AOI2BB2XL $PINS Y=n509 B1=MEMWriteData[6] B0=FE_OFN134_n319 A1N=n1186
+ A0N=FE_OFN131_n302
XU1102 OAI221XL $PINS Y=n656 C0=n512 B1=n303 B0=n1069 A1=FE_OFN129_n306
+ A0=n1104
XU1103 AOI2BB2XL $PINS Y=n512 B1=MEMWriteData[5] B0=n321 A1N=n1177
+ A0N=FE_OFN131_n302
XU1104 OAI221XL $PINS Y=n657 C0=n515 B1=n303 B0=n1070 A1=FE_OFN129_n306
+ A0=n1105
XU1105 AOI2BB2XL $PINS Y=n515 B1=MEMWriteData[4] B0=n320 A1N=n842
+ A0N=FE_OFN131_n302
XU1106 OAI221XL $PINS Y=n658 C0=n518 B1=n453 B0=n1071 A1=FE_OFN129_n306
+ A0=n1106
XU1107 AOI2BB2XL $PINS Y=n518 B1=MEMWriteData[3] B0=FE_OFN134_n319 A1N=n1153
+ A0N=FE_OFN131_n302
XU1108 OAI221XL $PINS Y=n659 C0=n521 B1=n303 B0=n1072 A1=FE_OFN129_n306
+ A0=n1107
XU1109 AOI2BB2XL $PINS Y=n521 B1=MEMWriteData[2] B0=n320 A1N=n1183
+ A0N=FE_OFN131_n302
XU1110 NOR2BX1 $PINS Y=n162 B=ID_EX[4] AN=n332
XU1111 AND2X2 $PINS Y=n163 B=n332 A=ID_EX[4]
XU1112 OAI2BB2XL $PINS Y=n669 B1=n332 B0=SPCASCAN_N0 A1N=n332 A0N=ID_MEM[0]
XU1113 OAI2BB2XL $PINS Y=n670 B1=n332 B0=SPCASCAN_N16 A1N=n332 A0N=ID_MEM[1]
XU1114 OAI2BB2XL $PINS Y=n671 B1=FE_OFN135_n332 B0=n634 A1N=FE_OFN135_n332
+ A0N=LTIE_LTIELO_NET
XU1115 OAI2BB2XL $PINS Y=n672 B1=n332 B0=n635 A1N=n332 A0N=ID_WB[0]
XU1116 CLKMX2X2 $PINS Y=n673 S0=n320 B=WB[1] A=ID_WB[1]
XU1117 OAI221X1 $PINS Y=ALUData1[31] C0=n363 B1=FE_OFN176_n273 B0=n1043 A1=n277
+ A0=n679
XU1118 OAI221X1 $PINS Y=ALUData1[30] C0=n365 B1=FE_OFN176_n273 B0=n1044 A1=n277
+ A0=n680
XU1119 OAI221X1 $PINS Y=ALUData1[29] C0=n366 B1=FE_OFN176_n273 B0=n1045 A1=n277
+ A0=n681
XU1120 OAI221X1 $PINS Y=ALUData1[28] C0=n369 B1=n273 B0=n1046 A1=n277 A0=n682
XU1121 OAI221X2 $PINS Y=ALUData1[27] C0=n370 B1=FE_OFN176_n273 B0=n1047 A1=n277
+ A0=n683
XU1122 NAND3BX1 $PINS Y=n1013 C=n1042 B=n444 AN=n372
XU1123 OAI221X2 $PINS Y=ALUData1[26] C0=n394 B1=FE_OFN176_n273 B0=n1048 A1=n277
+ A0=n684
XU1124 OAI221X2 $PINS Y=ALUData1[25] C0=n409 B1=FE_OFN176_n273 B0=n1049 A1=n277
+ A0=n685
XU1125 OAI221X2 $PINS Y=ALUData1[24] C0=n426 B1=FE_OFN176_n273 B0=n1050 A1=n277
+ A0=n686
XU1126 OAI221X2 $PINS Y=ALUData1[23] C0=n466 B1=FE_OFN176_n273 B0=n1051 A1=n277
+ A0=n687
XU1127 OAI221X2 $PINS Y=ALUData1[22] C0=n493 B1=FE_OFN176_n273 B0=n1052 A1=n277
+ A0=n688
XU1128 OAI221X1 $PINS Y=ALUData1[21] C0=n522 B1=FE_OFN176_n273 B0=n1053 A1=n277
+ A0=n689
XU1129 OAI221X2 $PINS Y=ALUData1[20] C0=n552 B1=FE_OFN176_n273 B0=n1054 A1=n277
+ A0=n690
XU1130 OAI221X2 $PINS Y=ALUData1[19] C0=n570 B1=FE_OFN176_n273 B0=n1055 A1=n277
+ A0=n691
XU1131 CLKINVX1 $PINS Y=n1018 A=n251
XU1132 OAI221X2 $PINS Y=ALUData1[18] C0=n591 B1=FE_OFN176_n273 B0=n1056 A1=n275
+ A0=n692
XU1133 OAI221X2 $PINS Y=ALUData1[17] C0=n615 B1=FE_OFN176_n273 B0=n1057 A1=n275
+ A0=n693
XU1134 OAI221X1 $PINS Y=ALUData1[16] C0=n719 B1=FE_OFN176_n273 B0=n1058 A1=n275
+ A0=n694
XU1135 OAI221X2 $PINS Y=ALUData1[15] C0=n747 B1=n273 B0=n1059 A1=n275 A0=n1156
XU1136 OAI221X2 $PINS Y=ALUData1[14] C0=n749 B1=n273 B0=n1060 A1=n275 A0=n1168
XU1137 OAI221X1 $PINS Y=ALUData1[13] C0=n762 B1=n273 B0=n1061 A1=n275 A0=n1162
XU1138 OAI221X1 $PINS Y=ALUData1[12] C0=n775 B1=n273 B0=n1062 A1=n275 A0=n1159
XU1139 OAI221X1 $PINS Y=ALUData1[11] C0=n788 B1=n273 B0=n1063 A1=n275 A0=n1165
XU1140 OAI221X1 $PINS Y=ALUData1[10] C0=n802 B1=n273 B0=n1064 A1=n275 A0=n1180
XU1141 OAI221X1 $PINS Y=n702 C0=n815 B1=n273 B0=n1065 A1=n275 A0=n1171
XU1142 OAI221X1 $PINS Y=ALUData1[8] C0=n828 B1=n273 B0=n1066 A1=n275 A0=n703
XU1143 OAI221X1 $PINS Y=ALUData1[7] C0=n840 B1=n273 B0=n1067 A1=n275 A0=n1174
XU1144 OAI221X2 $PINS Y=ALUData1[6] C0=n853 B1=n273 B0=n1068 A1=n275 A0=n1186
XU1145 OAI221X2 $PINS Y=ALUData1[5] C0=n865 B1=n273 B0=n1069 A1=n275 A0=n1177
XU1146 OAI221X2 $PINS Y=ALUData1[4] C0=n878 B1=n273 B0=n1070 A1=n275 A0=n842
XU1147 OAI221X2 $PINS Y=ALUData2[4] C0=n879 B1=n1116 B0=n250 A1=n283 A0=n842
XU1148 OAI221X1 $PINS Y=ALUData1[2] C0=n903 B1=n273 B0=n1072 A1=n275 A0=n1183
XU1149 OAI221X1 $PINS Y=ALUData1[1] C0=n915 B1=n1039 B0=n273 A1=n275 A0=n710
XU1150 OAI221X1 $PINS Y=ALUData1[0] C0=n929 B1=n1035 B0=n273 A1=n275 A0=n1149
Xlte_117 Execution_DW_cmp_0 $PINS A[31]=ALUData1[31] A[30]=ALUData1[30]
+ A[29]=ALUData1[29] A[28]=ALUData1[28] A[27]=ALUData1[27] A[26]=ALUData1[26]
+ A[25]=ALUData1[25] A[24]=ALUData1[24] A[23]=ALUData1[23] A[22]=ALUData1[22]
+ A[21]=ALUData1[21] A[20]=ALUData1[20] A[19]=ALUData1[19] A[18]=ALUData1[18]
+ A[17]=ALUData1[17] A[16]=ALUData1[16] A[15]=ALUData1[15] A[14]=ALUData1[14]
+ A[13]=ALUData1[13] A[12]=ALUData1[12] A[11]=ALUData1[11] A[10]=ALUData1[10]
+ A[9]=n702 A[8]=ALUData1[8] A[7]=ALUData1[7] A[6]=ALUData1[6] A[5]=ALUData1[5]
+ A[4]=ALUData1[4] A[3]=ALUData1[3] A[2]=ALUData1[2] A[1]=ALUData1[1]
+ A[0]=ALUData1[0] B[31]=n251 B[30]=n252 B[29]=n253 B[28]=n254 B[27]=n255
+ B[26]=n259 B[25]=n260 B[24]=n261 B[23]=n262 B[22]=n263 B[21]=n264 B[20]=n265
+ B[19]=n266 B[18]=n267 B[17]=n270 B[16]=n271 B[15]=ALUData2[15] B[14]=n108
+ B[13]=ALUData2[13] B[12]=ALUData2[12] B[11]=n134 B[10]=ALUData2[10]
+ B[9]=ALUData2[9] B[8]=ALUData2[8] B[7]=ALUData2[7] B[6]=ALUData2[6]
+ B[5]=ALUData2[5] B[4]=ALUData2[4] B[3]=ALUData2[3] B[2]=ALUData2[2]
+ B[1]=ALUData2[1] B[0]=n5 TC=VSS GE_LT=VSS GE_GT_EQ=VSS GE_LT_GT_LE=N524
+ n676=n676 n820=n820 n908=n908 n807=n807 n964=n964 n832=n832 n780=n780 n737=n737
+ n895=n895 n977=n977 n794=n794 n767=n767 n235=n235 n846=n846 n236=n236 n620=n620
+ n606=n606 n623=n623 n943=n943 n624=n624 n621=n621 n725=n725 n724=n724 n727=n727
+ n998=n998 n1018=n1018 n728=n728 n237=n237 n954=n954 n582=n582
Xsrl_80 Execution_DW_rightsh_0 $PINS A[31]=n251 A[30]=n252 A[29]=n253
+ A[28]=n254 A[27]=n255 A[26]=n259 A[25]=n260 A[24]=n261 A[23]=n262 A[22]=n263
+ A[21]=n264 A[20]=n265 A[19]=n266 A[18]=n267 A[17]=n270 A[16]=n271
+ A[15]=ALUData2[15] A[14]=n108 A[13]=ALUData2[13] A[12]=ALUData2[12] A[11]=n134
+ A[10]=ALUData2[10] A[9]=ALUData2[9] A[8]=ALUData2[8] A[7]=ALUData2[7]
+ A[6]=ALUData2[6] A[5]=ALUData2[5] A[4]=ALUData2[4] A[3]=ALUData2[3]
+ A[2]=ALUData2[2] A[1]=ALUData2[1] A[0]=n5 DATA_TC=VSS SH[4]=n317 SH[3]=n315
+ SH[2]=n311 SH[1]=n309 SH[0]=n307 B[31]=N395 B[30]=N394 B[29]=N393 B[28]=N392
+ B[27]=N391 B[26]=N390 B[25]=N389 B[24]=N388 B[23]=N387 B[22]=N386 B[21]=N385
+ B[20]=N384 B[19]=N383 B[18]=N382 B[17]=N381 B[16]=N380 B[15]=N379 B[14]=N378
+ B[13]=N377 B[12]=N376 B[11]=N375 B[10]=N374 B[9]=N373 B[8]=N372 B[7]=N371
+ B[6]=N370 B[5]=N369 B[4]=N368 B[3]=N367 B[2]=N366 B[1]=N365 B[0]=N364 n921=n921
+ n234=n234
Xsll_79 Execution_DW_leftsh_0 $PINS A[31]=n251 A[30]=n252 A[29]=n253 A[28]=n254
+ A[27]=n255 A[26]=n259 A[25]=n260 A[24]=n261 A[23]=n262 A[22]=n263 A[21]=n264
+ A[20]=n265 A[19]=n266 A[18]=n267 A[17]=n270 A[16]=n271 A[15]=ALUData2[15]
+ A[14]=n108 A[13]=ALUData2[13] A[12]=ALUData2[12] A[11]=n134 A[10]=ALUData2[10]
+ A[9]=ALUData2[9] A[8]=ALUData2[8] A[7]=ALUData2[7] A[6]=ALUData2[6]
+ A[5]=ALUData2[5] A[4]=ALUData2[4] A[3]=ALUData2[3] A[2]=ALUData2[2]
+ A[1]=ALUData2[1] A[0]=n5 SH[4]=n317 SH[3]=n315 SH[2]=n311 SH[1]=n309 SH[0]=n307
+ B[31]=N363 B[30]=N362 B[29]=N361 B[28]=N360 B[27]=N359 B[26]=N358 B[25]=N357
+ B[24]=N356 B[23]=N355 B[22]=N354 B[21]=N353 B[20]=N352 B[19]=N351 B[18]=N350
+ B[17]=N349 B[16]=N348 B[15]=N347 B[14]=N346 B[13]=N345 B[12]=N344 B[11]=N343
+ B[10]=N342 B[9]=N341 B[8]=N340 B[7]=N339 B[6]=N338 B[5]=N337 B[4]=N336
+ B[3]=N335 B[2]=N334 B[1]=N333 B[0]=N332 FE_PT1_n245=FE_OFN210_n245
+ FE_PT1_n249=n249
Xsub_74 Execution_DW01_sub_1 $PINS A[31]=ALUData1[31] A[30]=ALUData1[30]
+ A[29]=ALUData1[29] A[28]=ALUData1[28] A[27]=ALUData1[27] A[26]=ALUData1[26]
+ A[25]=ALUData1[25] A[24]=ALUData1[24] A[23]=ALUData1[23] A[22]=ALUData1[22]
+ A[21]=ALUData1[21] A[20]=ALUData1[20] A[19]=ALUData1[19] A[18]=ALUData1[18]
+ A[17]=ALUData1[17] A[16]=ALUData1[16] A[15]=ALUData1[15] A[14]=ALUData1[14]
+ A[13]=ALUData1[13] A[12]=ALUData1[12] A[11]=ALUData1[11] A[10]=ALUData1[10]
+ A[9]=n702 A[8]=ALUData1[8] A[7]=ALUData1[7] A[6]=ALUData1[6] A[5]=ALUData1[5]
+ A[4]=ALUData1[4] A[3]=ALUData1[3] A[2]=ALUData1[2] A[1]=ALUData1[1]
+ A[0]=ALUData1[0] B[31]=n251 B[30]=n252 B[29]=n253 B[28]=n254 B[27]=n255
+ B[26]=n259 B[25]=n260 B[24]=n261 B[23]=n262 B[22]=n263 B[21]=n264 B[20]=n265
+ B[19]=n266 B[18]=n267 B[17]=n270 B[16]=n271 B[15]=ALUData2[15] B[14]=n108
+ B[13]=ALUData2[13] B[12]=ALUData2[12] B[11]=ALUData2[11] B[10]=ALUData2[10]
+ B[9]=ALUData2[9] B[8]=ALUData2[8] B[7]=ALUData2[7] B[6]=ALUData2[6]
+ B[5]=ALUData2[5] B[4]=ALUData2[4] B[3]=ALUData2[3] B[2]=ALUData2[2]
+ B[1]=ALUData2[1] B[0]=n5 CI=VSS DIFF[31]=N235 DIFF[30]=N234 DIFF[29]=N233
+ DIFF[28]=N232 DIFF[27]=N231 DIFF[26]=N230 DIFF[25]=N229 DIFF[24]=N228
+ DIFF[23]=N227 DIFF[22]=N226 DIFF[21]=N225 DIFF[20]=N224 DIFF[19]=N223
+ DIFF[18]=N222 DIFF[17]=N221 DIFF[16]=N220 DIFF[15]=N219 DIFF[14]=N218
+ DIFF[13]=N217 DIFF[12]=N216 DIFF[11]=N215 DIFF[10]=N214 DIFF[9]=N213
+ DIFF[8]=N212 DIFF[7]=N211 DIFF[6]=N210 DIFF[5]=N209 DIFF[4]=N208 DIFF[3]=N207
+ DIFF[2]=N206 DIFF[1]=N205 DIFF[0]=N204 FE_PT1_n235=n235 n896=n896
+ FE_PT1_n236=n236 n954=n954 FE_PT1_n237=n237 n821=n821 n808=n808 n781=n781
+ n921=n921 FE_PT1_n234=n234 n846=n846 n1018=n1018 n998=n998 n978=n978 n965=n965
+ n833=n833 n606=n606 n727=n727 n728=n728 n738=n738 n943=n943 n768=n768 n620=n620
+ n724=n724 n725=n725 n621=n621 n582=n582 n677=n677 n624=n624 n623=n623
Xadd_73 Execution_DW01_add_1 $PINS A[31]=ALUData1[31] A[30]=ALUData1[30]
+ A[29]=ALUData1[29] A[28]=ALUData1[28] A[27]=ALUData1[27] A[26]=ALUData1[26]
+ A[25]=ALUData1[25] A[24]=ALUData1[24] A[23]=ALUData1[23] A[22]=ALUData1[22]
+ A[21]=ALUData1[21] A[20]=ALUData1[20] A[19]=ALUData1[19] A[18]=ALUData1[18]
+ A[17]=ALUData1[17] A[16]=ALUData1[16] A[15]=ALUData1[15] A[14]=ALUData1[14]
+ A[13]=ALUData1[13] A[12]=ALUData1[12] A[11]=ALUData1[11] A[10]=ALUData1[10]
+ A[9]=n702 A[8]=ALUData1[8] A[7]=ALUData1[7] A[6]=ALUData1[6] A[5]=ALUData1[5]
+ A[4]=ALUData1[4] A[3]=ALUData1[3] A[2]=ALUData1[2] A[1]=ALUData1[1]
+ A[0]=ALUData1[0] B[31]=n251 B[30]=n252 B[29]=n253 B[28]=n254 B[27]=n255
+ B[26]=n259 B[25]=n260 B[24]=n261 B[23]=n262 B[22]=n263 B[21]=n264 B[20]=n265
+ B[19]=n266 B[18]=n267 B[17]=n270 B[16]=n271 B[15]=ALUData2[15] B[14]=n108
+ B[13]=ALUData2[13] B[12]=ALUData2[12] B[11]=ALUData2[11] B[10]=ALUData2[10]
+ B[9]=ALUData2[9] B[8]=ALUData2[8] B[7]=ALUData2[7] B[6]=ALUData2[6]
+ B[5]=ALUData2[5] B[4]=ALUData2[4] B[3]=ALUData2[3] B[2]=ALUData2[2]
+ B[1]=ALUData2[1] B[0]=n5 CI=VSS SUM[31]=N203 SUM[30]=N202 SUM[29]=N201
+ SUM[28]=N200 SUM[27]=N199 SUM[26]=N198 SUM[25]=N197 SUM[24]=N196 SUM[23]=N195
+ SUM[22]=N194 SUM[21]=N193 SUM[20]=N192 SUM[19]=N191 SUM[18]=N190 SUM[17]=N189
+ SUM[16]=N188 SUM[15]=N187 SUM[14]=N186 SUM[13]=N185 SUM[12]=N184 SUM[11]=N183
+ SUM[10]=N182 SUM[9]=N181 SUM[8]=N180 SUM[7]=N179 SUM[6]=N178 SUM[5]=N177
+ SUM[4]=N176 SUM[3]=N175 SUM[2]=N174 SUM[1]=N173 SUM[0]=N172
XU160 INVX3 $PINS Y=n1129 A=n1131
XU1151 INVX12 $PINS Y=MEMWriteData[1] A=n1129
XWB_reg[0] SDFFRXL $PINS SI=SPCASCAN_N17 SE=FE_OFN8_test_se_i RN=n341 QN=n635
+ Q=WB[0] D=n672 CK=clk_i__L3_N9
XMEM_reg[2] SDFFRXL $PINS SI=SPCASCAN_N22 SE=FE_OFN98_test_se_i RN=n341 QN=n634
+ Q=MEM[2] D=n671 CK=clk_i__L3_N11
XALUresult_reg[14] SDFFRXL $PINS SI=SPCASCAN_N8 SE=FE_OFN21_test_se_i
+ RN=FE_OFN165_n341 QN=n696 Q=SPCBSCAN_N39 D=next_ALUresult[14] CK=clk_i__L3_N2
XALUresult_reg[11] SDFFRXL $PINS SI=n81 SE=FE_OFN21_test_se_i RN=FE_OFN166_n342
+ QN=n699 Q=n91 D=next_ALUresult[11] CK=clk_i__L3_N2
XALUresult_reg[13] SDFFRXL $PINS SI=n82 SE=FE_OFN21_test_se_i RN=FE_OFN165_n341
+ QN=n697 Q=SPCASCAN_N8 D=next_ALUresult[13] CK=clk_i__L3_N2
XALUresult_reg[6] SDFFRXL $PINS SI=n83 SE=FE_OFN93_test_se_i RN=FE_OFN167_n343
+ QN=n705 Q=n89 D=next_ALUresult[6] CK=clk
XALUresult_reg[3] SDFFRXL $PINS SI=ALUresult[4] SE=FE_OFN15_test_se_i
+ RN=FE_OFN167_n343 QN=n708 Q=n88 D=next_ALUresult[3] CK=clk
XALUresult_reg[2] SDFFRXL $PINS SI=ALUresult[1] SE=test_se RN=FE_OFN167_n343
+ QN=n709 Q=n87 D=next_ALUresult[2] CK=clk
XALUresult_reg[10] SDFFRXL $PINS SI=SPCASCAN_N12 SE=FE_OFN21_test_se_i
+ RN=FE_OFN166_n342 QN=n700 Q=n86 D=next_ALUresult[10] CK=clk_i__L3_N2
XALUresult_reg[24] SDFFRXL $PINS SI=ALUresult[19] SE=FE_OFN94_test_se_i
+ RN=FE_OFN165_n341 QN=n686 Q=n430 D=next_ALUresult[24] CK=clk_i__L3_N11
XALUresult_reg[27] SDFFRXL $PINS SI=n68 SE=FE_OFN98_test_se_i RN=FE_OFN165_n341
+ QN=n683 Q=n1122 D=next_ALUresult[27] CK=clk_i__L3_N11
XALUresult_reg[22] SDFFRXL $PINS SI=ALUresult[24] SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n688 Q=n1125 D=next_ALUresult[22] CK=clk_i__L3_N11
XALUresult_reg[5] SDFFRXL $PINS SI=n89 SE=FE_OFN93_test_se_i RN=FE_OFN167_n343
+ QN=n706 Q=n85 D=next_ALUresult[5] CK=clk
XALUresult_reg[25] SDFFRXL $PINS SI=n74 SE=FE_OFN95_test_se_i RN=FE_OFN165_n341
+ QN=n685 Q=n411 D=next_ALUresult[25] CK=clk_i__L3_N11
XALUresult_reg[31] SDFFRXL $PINS SI=n42 SE=FE_OFN98_test_se_i RN=FE_OFN166_n342
+ QN=n679 Q=n1121 D=next_ALUresult[31] CK=clk_i__L3_N11
XALUresult_reg[26] SDFFRXL $PINS SI=n76 SE=FE_OFN98_test_se_i RN=n341 QN=n684
+ Q=n1123 D=next_ALUresult[26] CK=clk_i__L3_N11
XALUresult_reg[23] SDFFRXL $PINS SI=n70 SE=FE_OFN95_test_se_i RN=FE_OFN165_n341
+ QN=n687 Q=n1124 D=next_ALUresult[23] CK=clk_i__L3_N11
XALUresult_reg[18] SDFFRXL $PINS SI=n49 SE=FE_OFN95_test_se_i RN=FE_OFN167_n343
+ QN=n692 Q=n1127 D=next_ALUresult[18] CK=clk_i__L3_N11
XALUresult_reg[19] SDFFRXL $PINS SI=ALUresult[21] SE=FE_OFN94_test_se_i
+ RN=FE_OFN165_n341 QN=n691 Q=n1126 D=next_ALUresult[19] CK=clk_i__L3_N11
XALUresult_reg[12] SDFFRXL $PINS SI=n91 SE=FE_OFN21_test_se_i RN=FE_OFN166_n342
+ QN=n698 Q=n84 D=next_ALUresult[12] CK=clk_i__L3_N2
XALUresult_reg[7] SDFFRXL $PINS SI=n84 SE=FE_OFN21_test_se_i RN=FE_OFN166_n342
+ QN=n704 Q=n83 D=next_ALUresult[7] CK=clk_i__L3_N2
XALUresult_reg[15] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_22_
+ SE=FE_OFN21_test_se_i RN=FE_OFN165_n341 QN=n695 Q=n82 D=next_ALUresult[15]
+ CK=clk_i__L3_N2
XALUresult_reg[9] SDFFRXL $PINS SI=ALUresult[8] SE=FE_OFN21_test_se_i
+ RN=FE_OFN166_n342 QN=n701 Q=n81 D=next_ALUresult[9] CK=clk_i__L3_N2
XALUresult_reg[0] SDFFRXL $PINS SI=n87 SE=FE_OFN96_test_se_i RN=FE_OFN166_n342
+ QN=n711 Q=n1128 D=next_ALUresult[0] CK=clk
XMEM_reg[1] SDFFRXL $PINS SI=n635 SE=FE_OFN8_test_se_i RN=n341 QN=SPCASCAN_N16
+ Q=MEM[1] D=n670 CK=clk_i__L3_N9
XMEM_reg[0] SDFFRXL $PINS SI=n40 SE=FE_OFN8_test_se_i RN=n341 QN=SPCASCAN_N0
+ Q=MEM[0] D=n669 CK=clk_i__L3_N9
XMEMWriteData_reg[19] SDFFRXL $PINS SI=ALUresult[25] SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n11 Q=n80 D=n637 CK=clk_i__L3_N11
XMEMWriteData_reg[21] SDFFRXL $PINS SI=n80 SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n12 Q=n78 D=n638 CK=clk_i__L3_N11
XMEMWriteData_reg[22] SDFFRXL $PINS SI=ALUresult[22] SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n13 Q=n76 D=n639 CK=clk_i__L3_N11
XMEMWriteData_reg[23] SDFFRXL $PINS SI=ALUresult[23] SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n14 Q=n74 D=n640 CK=clk_i__L3_N11
XMEMWriteData_reg[24] SDFFRXL $PINS SI=ALUresult[28] SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n15 Q=n72 D=n641 CK=clk_i__L3_N11
XMEMWriteData_reg[25] SDFFRXL $PINS SI=n72 SE=FE_OFN95_test_se_i
+ RN=FE_OFN165_n341 QN=n16 Q=n70 D=n642 CK=clk_i__L3_N11
XMEMWriteData_reg[26] SDFFRXL $PINS SI=ALUresult[26] SE=FE_OFN98_test_se_i
+ RN=n341 QN=n17 Q=n68 D=n643 CK=clk_i__L3_N11
XMEMWriteData_reg[15] SDFFRXL $PINS SI=n56 SE=FE_OFN94_test_se_i
+ RN=FE_OFN165_n341 QN=n18 Q=n66 D=n646 CK=clk_i__L3_N11
XMEMWriteData_reg[14] SDFFRXL $PINS SI=n57 SE=FE_OFN94_test_se_i
+ RN=FE_OFN165_n341 QN=n19 Q=n64 D=n647 CK=clk_i__L3_N11
XMEMWriteData_reg[13] SDFFRXL $PINS SI=n60 SE=FE_OFN94_test_se_i
+ RN=FE_OFN165_n341 QN=n20 Q=n62 D=n648 CK=clk
XMEMWriteData_reg[12] SDFFRXL $PINS SI=n58 SE=FE_OFN94_test_se_i
+ RN=FE_OFN166_n342 QN=n21 Q=n60 D=n649 CK=clk
XMEMWriteData_reg[11] SDFFRXL $PINS SI=ALUresult[17] SE=FE_OFN95_test_se_i
+ RN=FE_OFN166_n342 QN=n22 Q=n59 D=n650 CK=clk_i__L3_N11
XMEMWriteData_reg[10] SDFFRXL $PINS SI=n66 SE=FE_OFN94_test_se_i
+ RN=FE_OFN166_n342 QN=n27 Q=n58 D=n651 CK=clk
XMEMWriteData_reg[9] SDFFRXL $PINS SI=n46 SE=FE_OFN95_test_se_i
+ RN=FE_OFN166_n342 QN=n28 Q=n57 D=n652 CK=clk_i__L3_N11
XMEMWriteData_reg[8] SDFFRXL $PINS SI=n64 SE=FE_OFN94_test_se_i
+ RN=FE_OFN166_n342 QN=n29 Q=n56 D=n653 CK=clk_i__L3_N11
XMEMWriteData_reg[7] SDFFRXL $PINS SI=n62 SE=FE_OFN94_test_se_i
+ RN=FE_OFN166_n342 QN=n30 Q=n55 D=n654 CK=clk
XMEMWriteData_reg[6] SDFFRXL $PINS SI=n55 SE=FE_OFN94_test_se_i
+ RN=FE_OFN167_n343 QN=n31 Q=n54 D=n655 CK=clk
XMEMWriteData_reg[5] SDFFRXL $PINS SI=n52 SE=FE_OFN96_test_se_i
+ RN=FE_OFN167_n343 QN=n32 Q=SPCASCAN_N9 D=n656 CK=clk
XMEMWriteData_reg[4] SDFFRXL $PINS SI=n1037 SE=FE_OFN96_test_se_i
+ RN=FE_OFN167_n343 QN=n33 Q=n52 D=n657 CK=clk
XMEMWriteData_reg[3] SDFFRXL $PINS SI=ALUresult[0] SE=FE_OFN96_test_se_i
+ RN=FE_OFN167_n343 QN=n34 Q=n51 D=n658 CK=clk
XMEMWriteData_reg[2] SDFFRXL $PINS SI=n51 SE=FE_OFN96_test_se_i
+ RN=FE_OFN167_n343 QN=n35 Q=SPCASCAN_N11 D=n659 CK=clk
XMEMWriteData_reg[17] SDFFRXL $PINS SI=ALUresult[16] SE=FE_OFN95_test_se_i
+ RN=FE_OFN167_n343 QN=n23 Q=n49 D=n661 CK=clk_i__L3_N11
XMEMWriteData_reg[18] SDFFRXL $PINS SI=ALUresult[20] SE=FE_OFN95_test_se_i
+ RN=FE_OFN167_n343 QN=n24 Q=n48 D=n662 CK=clk_i__L3_N11
XMEMWriteData_reg[20] SDFFRXL $PINS SI=n78 SE=FE_OFN95_test_se_i
+ RN=FE_OFN167_n343 QN=n25 Q=n47 D=n663 CK=clk_i__L3_N11
XMEMWriteData_reg[16] SDFFRXL $PINS SI=n59 SE=FE_OFN95_test_se_i
+ RN=FE_OFN167_n343 QN=n26 Q=n46 D=n665 CK=clk_i__L3_N11
XMEMWriteData_reg[27] SDFFRXL $PINS SI=n44 SE=FE_OFN98_test_se_i RN=n341
+ QN=n1031 Q=n45 D=n644 CK=clk_i__L3_N11
XMEMWriteData_reg[28] SDFFRXL $PINS SI=n43 SE=FE_OFN98_test_se_i RN=n341
+ QN=n1030 Q=n44 D=n645 CK=clk_i__L3_N11
XMEMWriteData_reg[29] SDFFRXL $PINS SI=ALUresult[27] SE=FE_OFN98_test_se_i
+ RN=n341 QN=n1029 Q=n43 D=n664 CK=clk_i__L3_N11
XMEMWriteData_reg[30] SDFFRXL $PINS SI=n45 SE=FE_OFN98_test_se_i RN=n341
+ QN=n1028 Q=n42 D=n666 CK=clk_i__L3_N11
XMEMWriteData_reg[31] SDFFRXL $PINS SI=n54 SE=FE_OFN98_test_se_i
+ RN=FE_OFN166_n342 QN=n1027 Q=n41 D=n667 CK=clk_i__L3_N11
XMEMWriteData_reg[0] SDFFRXL $PINS SI=n41 SE=FE_OFN98_test_se_i
+ RN=FE_OFN166_n342 QN=n1033 Q=n40 D=n668 CK=clk_i__L3_N11
XRegisterRd_reg[2] SDFFRXL $PINS SI=test_so SE=FE_OFN98_test_se_i RN=rst QN=n39
+ Q=RegisterRd[2] D=n1075 CK=clk_i__L3_N9
XRegisterRd_reg[0] SDFFRXL $PINS SI=n36 SE=FE_OFN98_test_se_i RN=n341
+ QN=SPCASCAN_N21 Q=RegisterRd[0] D=n1077 CK=clk_i__L3_N9
XALUresult_reg[1] SDFFRXL $PINS SI=n88 SE=test_se RN=FE_OFN167_n343 QN=n710
+ Q=n917 D=next_ALUresult[1] CK=clk
XALUresult_reg[8] SDFFRXL $PINS SI=n86 SE=FE_OFN21_test_se_i RN=FE_OFN166_n342
+ QN=n703 Q=n829 D=next_ALUresult[8] CK=clk_i__L3_N2
XALUresult_reg[21] SDFFRXL $PINS SI=n48 SE=FE_OFN95_test_se_i RN=FE_OFN165_n341
+ QN=n689 Q=n524 D=next_ALUresult[21] CK=clk_i__L3_N11
XALUresult_reg[20] SDFFRXL $PINS SI=ALUresult[18] SE=FE_OFN95_test_se_i
+ RN=FE_OFN167_n343 QN=n690 Q=n554 D=next_ALUresult[20] CK=clk_i__L3_N11
XALUresult_reg[28] SDFFRXL $PINS SI=ALUresult[29] SE=FE_OFN94_test_se_i
+ RN=FE_OFN165_n341 QN=n682 Q=n961 D=next_ALUresult[28] CK=clk_i__L3_N11
XALUresult_reg[29] SDFFRXL $PINS SI=ALUresult[30] SE=FE_OFN98_test_se_i
+ RN=FE_OFN167_n343 QN=n681 Q=n974 D=next_ALUresult[29] CK=clk_i__L3_N11
XALUresult_reg[16] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_21_
+ SE=FE_OFN95_test_se_i RN=FE_OFN167_n343 QN=n694 Q=n721 D=next_ALUresult[16]
+ CK=clk_i__L3_N11
XALUresult_reg[4] SDFFRXL $PINS SI=n85 SE=FE_OFN93_test_se_i RN=FE_OFN167_n343
+ QN=n707 Q=n880 D=next_ALUresult[4] CK=clk
XALUresult_reg[17] SDFFRXL $PINS SI=n47 SE=FE_OFN95_test_se_i RN=FE_OFN167_n343
+ QN=n693 Q=n617 D=next_ALUresult[17] CK=clk_i__L3_N11
XALUresult_reg[30] SDFFRXL $PINS SI=ALUresult[31] SE=FE_OFN98_test_se_i RN=n341
+ QN=n680 Q=n990 D=next_ALUresult[30] CK=clk_i__L3_N11
XWB_reg[1] SDFFRXL $PINS SI=MEM[2] SE=FE_OFN98_test_se_i RN=n341 QN=test_so
+ Q=n1189 D=n673 CK=clk_i__L3_N9
XRegisterRd_reg[4] SDFFRXL $PINS SI=n3 SE=FE_OFN98_test_se_i RN=n341 QN=n36
+ Q=RegisterRd[4] D=n1073 CK=clk_i__L3_N9
XRegisterRd_reg[3] SDFFRX2 $PINS SI=n39 SE=FE_OFN98_test_se_i RN=n341 QN=n4
+ Q=RegisterRd[3] D=n1074 CK=clk_i__L3_N9
XRegisterRd_reg[1] SDFFRX2 $PINS SI=n4 SE=FE_OFN98_test_se_i RN=n341 QN=n3
+ Q=RegisterRd[1] D=n1076 CK=clk_i__L3_N9
XMEMWriteData_reg[1] SDFFRXL $PINS SI=SPCASCAN_N10 SE=FE_OFN97_test_se_i RN=rst
+ QN=n1037 Q=n1131 D=n660 CK=clk_i__L3_N11
XU2 CLKBUFX2 $PINS Y=n94 A=n695
XU7 CLKBUFX2 $PINS Y=n95 A=n698
XU8 CLKBUFX2 $PINS Y=n96 A=n697
XU9 CLKBUFX2 $PINS Y=n97 A=n699
XU1152 CLKBUFX2 $PINS Y=n104 A=n701
XU1158 INVXL $PINS Y=n817 A=n707
XU1159 INVXL $PINS Y=n842 A=n817
XU1161 CLKINVX1 $PINS Y=n868 A=n1033
XU1162 CLKINVX1 $PINS Y=n892 A=n868
XU1163 INVXL $PINS Y=n905 A=n868
XU1164 CLKINVX1 $PINS Y=n950 A=n1027
XU1165 CLKINVX3 $PINS Y=n1041 A=n950
XU1167 CLKINVX1 $PINS Y=n1132 A=n1028
XU1168 CLKINVX3 $PINS Y=n1133 A=n1132
XU1170 CLKINVX1 $PINS Y=n1135 A=n1029
XU1171 CLKINVX3 $PINS Y=n1136 A=n1135
XU1173 CLKINVX1 $PINS Y=n1138 A=n1030
XU1174 CLKINVX3 $PINS Y=n1139 A=n1138
XU1176 CLKINVX1 $PINS Y=n1141 A=n1031
XU1177 CLKINVX3 $PINS Y=n1142 A=n1141
XU1179 INVXL $PINS Y=n1144 A=n1189
XU1180 INVXL $PINS Y=WB[1] A=n1144
XU1182 INVXL $PINS Y=n1147 A=n711
XU1184 INVXL $PINS Y=n1149 A=n1147
XU1187 INVXL $PINS Y=n1152 A=n708
XU1188 INVXL $PINS Y=n1153 A=n1152
XU1190 INVXL $PINS Y=n1155 A=n695
XU1191 INVXL $PINS Y=n1156 A=n1155
XU1193 INVXL $PINS Y=n1158 A=n698
XU1194 INVXL $PINS Y=n1159 A=n1158
XU1196 INVXL $PINS Y=n1161 A=n697
XU1197 INVXL $PINS Y=n1162 A=n1161
XU1199 INVXL $PINS Y=n1164 A=n699
XU1200 INVXL $PINS Y=n1165 A=n1164
XU1202 INVXL $PINS Y=n1167 A=n696
XU1203 INVXL $PINS Y=n1168 A=n1167
XU1205 INVXL $PINS Y=n1170 A=n701
XU1206 INVXL $PINS Y=n1171 A=n1170
XU1208 INVXL $PINS Y=n1173 A=n704
XU1209 CLKINVX1 $PINS Y=n1174 A=n1173
XU1211 INVXL $PINS Y=n1176 A=n706
XU1212 INVXL $PINS Y=n1177 A=n1176
XU1214 INVXL $PINS Y=n1179 A=n700
XU1215 INVXL $PINS Y=n1180 A=n1179
XU1217 INVXL $PINS Y=n1182 A=FE_OFN224_n709
XU1218 INVXL $PINS Y=n1183 A=n1182
XU1220 INVXL $PINS Y=n1185 A=n705
XU1221 INVXL $PINS Y=n1186 A=n1185
.ENDS

.SUBCKT InstructionDecode_DW_mult_uns_1 a[31] a[30] a[29] a[28] a[27] a[26]
+ a[25] a[24] a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15] a[14] a[13]
+ a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b
+ product[32] product[31] product[30] product[29] product[28] product[27]
+ product[26] product[25] product[24] product[23] product[22] product[21]
+ product[20] product[19] product[18] product[17] product[16] product[15]
+ product[14] product[13] product[12] product[11] product[10] product[9]
+ product[8] product[7] product[6] product[5] product[4] product[3] product[2]
+ product[1] product[0]
XU67 CLKBUFX3 $PINS Y=n2 A=n33
XU68 NOR2X1 $PINS Y=product[14] B=n20 A=n33
XU69 NOR2X1 $PINS Y=product[17] B=n17 A=n2
XU70 NOR2X1 $PINS Y=product[10] B=n24 A=n33
XU71 NOR2X1 $PINS Y=product[16] B=n18 A=n33
XU72 NOR2X1 $PINS Y=product[23] B=n11 A=n2
XU73 NOR2X1 $PINS Y=product[13] B=n21 A=n33
XU74 NOR2X1 $PINS Y=product[19] B=n15 A=n2
XU75 NOR2X1 $PINS Y=product[9] B=n25 A=n33
XU76 NOR2X1 $PINS Y=product[25] B=n9 A=n2
XU77 NOR2X1 $PINS Y=product[24] B=n10 A=n2
XU78 NOR2X1 $PINS Y=product[12] B=n22 A=n33
XU79 NOR2X1 $PINS Y=product[7] B=n27 A=n33
XU80 NOR2X1 $PINS Y=product[2] B=n32 A=n33
XU81 NOR2X1 $PINS Y=product[8] B=n26 A=n33
XU82 NOR2X1 $PINS Y=product[6] B=n28 A=n33
XU83 INVX2 $PINS Y=n33 A=b
XU84 NOR2X1 $PINS Y=product[22] B=n12 A=n2
XU86 NOR2XL $PINS Y=product[4] B=n30 A=n33
XU87 NOR2XL $PINS Y=product[20] B=n14 A=n2
XU88 NOR2XL $PINS Y=product[21] B=n13 A=n2
XU89 NOR2XL $PINS Y=product[5] B=n29 A=n33
XU90 NOR2XL $PINS Y=product[26] B=n8 A=n2
XU91 NOR2XL $PINS Y=product[27] B=n7 A=n2
XU92 NOR2XL $PINS Y=product[28] B=n6 A=n2
XU93 NOR2XL $PINS Y=product[29] B=n5 A=n2
XU94 NOR2XL $PINS Y=product[30] B=n4 A=n2
XU95 NOR2XL $PINS Y=product[31] B=n3 A=n2
XU96 CLKINVX1 $PINS Y=n29 A=a[5]
XU97 CLKINVX1 $PINS Y=n27 A=a[7]
XU98 CLKINVX1 $PINS Y=n25 A=a[9]
XU99 CLKINVX1 $PINS Y=n17 A=a[17]
XU100 NOR2X1 $PINS Y=product[15] B=n19 A=n33
XU101 CLKINVX1 $PINS Y=n19 A=a[15]
XU102 CLKINVX1 $PINS Y=n21 A=a[13]
XU103 NOR2X1 $PINS Y=product[11] B=n23 A=n33
XU104 CLKINVX1 $PINS Y=n23 A=a[11]
XU105 CLKINVX1 $PINS Y=n11 A=a[23]
XU106 CLKINVX1 $PINS Y=n13 A=a[21]
XU107 CLKINVX1 $PINS Y=n15 A=a[19]
XU108 CLKINVX1 $PINS Y=n7 A=a[27]
XU109 CLKINVX1 $PINS Y=n5 A=a[29]
XU110 CLKINVX1 $PINS Y=n6 A=a[28]
XU111 CLKINVX1 $PINS Y=n32 A=a[2]
XU112 NOR2X1 $PINS Y=product[3] B=n31 A=n33
XU113 CLKINVX1 $PINS Y=n31 A=a[3]
XU114 CLKINVX1 $PINS Y=n28 A=a[6]
XU115 CLKINVX1 $PINS Y=n22 A=a[12]
XU116 CLKINVX1 $PINS Y=n20 A=a[14]
XU117 CLKINVX1 $PINS Y=n18 A=a[16]
XU118 NOR2X1 $PINS Y=product[18] B=n16 A=n2
XU119 CLKINVX1 $PINS Y=n16 A=a[18]
XU120 CLKINVX1 $PINS Y=n12 A=a[22]
XU121 CLKINVX1 $PINS Y=n10 A=a[24]
XU122 CLKINVX1 $PINS Y=n9 A=a[25]
XU123 CLKINVX1 $PINS Y=n4 A=a[30]
XU124 CLKINVX1 $PINS Y=n8 A=a[26]
XU125 CLKINVX1 $PINS Y=n30 A=a[4]
XU126 CLKINVX1 $PINS Y=n26 A=a[8]
XU127 CLKINVX1 $PINS Y=n24 A=a[10]
XU128 CLKINVX1 $PINS Y=n14 A=a[20]
XU129 CLKINVX1 $PINS Y=n3 A=a[31]
.ENDS

.SUBCKT InstructionDecode_DW01_add_2 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25]
+ SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16]
+ SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6]
+ SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO n4586
XU254 NOR2X1 $PINS Y=n125 B=A[15] A=B[15]
XU255 NOR2X1 $PINS Y=n153 B=A[10] A=B[10]
XU257 NOR2X1 $PINS Y=n57 B=n59 A=n86
XU259 NOR2X1 $PINS Y=n111 B=n113 A=n118
XU260 NOR2X1 $PINS Y=n118 B=A[16] A=B[16]
XU262 OAI21XL $PINS Y=n124 B0=n126 A1=n131 A0=n125
XU263 NOR2X1 $PINS Y=n98 B=A[19] A=B[19]
XU264 NAND2X1 $PINS Y=n175 B=A[6] A=B[6]
XU265 OAI21XL $PINS Y=n179 B0=n181 A1=n184 A0=n180
XU267 NOR2X1 $PINS Y=n88 B=n90 A=n93
XU268 NOR2X1 $PINS Y=n93 B=A[20] A=B[20]
XU269 NAND2X1 $PINS Y=n154 B=A[10] A=B[10]
XU270 OAI21XL $PINS Y=n112 B0=n114 A1=n119 A0=n113
XU271 OAI21XL $PINS Y=n186 B0=n188 A1=n190 A0=n187
XU272 NAND2X1 $PINS Y=n190 B=A[2] A=B[2]
XU275 NOR2X1 $PINS Y=n148 B=n150 A=n153
XU276 NOR2X1 $PINS Y=n177 B=n179 A=n349
XU278 OAI21XL $PINS Y=n160 B0=n162 A1=n165 A0=n161
XU279 NOR2X1 $PINS Y=n159 B=n161 A=n164
XU280 NOR2X1 $PINS Y=n161 B=A[9] A=B[9]
XU281 NOR2X1 $PINS Y=n87 B=n89 A=n354
XU282 NAND2X1 $PINS Y=n145 B=n147 A=n344
XU283 NAND2X1 $PINS Y=n344 B=n343 A=n342
XU284 CLKINVX1 $PINS Y=n343 A=n146
XU285 NOR2X1 $PINS Y=n345 B=n134 A=n155
XU286 XNOR2XL $PINS Y=SUM[18] B=n14 A=n105
XU287 NAND2X1 $PINS Y=n109 B=n111 A=n123
XU288 AND2X2 $PINS Y=n349 B=n178 A=n186
XU289 NOR2X1 $PINS Y=n178 B=n180 A=n183
XU290 OR2X1 $PINS Y=n168 B=n359 A=n358
XU291 NOR2X1 $PINS Y=n358 B=n175 A=n169
XU292 CLKINVX1 $PINS Y=n340 A=n154
XU293 CLKINVX1 $PINS Y=n342 A=n155
XU296 NOR2X1 $PINS Y=n80 B=A[22] A=B[22]
XU297 NAND2X1 $PINS Y=n184 B=A[4] A=n335
XU299 AO21X1 $PINS Y=n120 B0=n124 A1=n123 A0=n133
XU301 NAND2X1 $PINS Y=n81 B=A[22] A=B[22]
XU303 AO21X1 $PINS Y=n363 B0=n142 A1=n141 A0=n145
XU304 AOI21X1 $PINS Y=n127 B0=n129 A1=n128 A0=n133
XU305 XOR2X1 $PINS Y=SUM[26] B=n56 A=n6
XU307 OA21XL $PINS Y=n364 B0=n55 A1=n54 A0=n56
XU308 CLKBUFX3 $PINS Y=n326 A=B[26]
XU310 OR2X1 $PINS Y=n328 B=A[28] A=B[28]
XU311 OR2X1 $PINS Y=n329 B=A[29] A=B[29]
XU312 NOR2X1 $PINS Y=n174 B=A[6] A=B[6]
XU313 NOR2X1 $PINS Y=n130 B=A[14] A=B[14]
XU314 CLKINVX1 $PINS Y=n339 A=n150
XU315 OAI21XL $PINS Y=n74 B0=n76 A1=n81 A0=n75
XU316 NAND2X1 $PINS Y=n76 B=A[23] A=B[23]
XU317 NAND2X1 $PINS Y=n64 B=A[25] A=B[25]
XU318 AOI21X1 $PINS Y=n158 B0=n160 A1=n159 A0=n168
XU319 NOR2X1 $PINS Y=n167 B=n169 A=n174
XU320 NOR2X1 $PINS Y=n183 B=A[4] A=n335
XU321 INVXL $PINS Y=n212 A=n153
XU322 NOR2X1 $PINS Y=n106 B=n108 A=n355
XU323 OAI21XL $PINS Y=n108 B0=n110 A1=n109 A0=n135
XU324 OAI21XL $PINS Y=n89 B0=n91 A1=n94 A0=n90
XU325 NOR2X1 $PINS Y=n90 B=A[21] A=B[21]
XU326 NAND2XL $PINS Y=n17 B=n126 A=n207
XU327 NAND2X1 $PINS Y=n126 B=A[15] A=B[15]
XU328 NOR2X1 $PINS Y=n110 B=n112 A=n348
XU329 INVXL $PINS Y=n101 A=n103
XU330 NOR2X1 $PINS Y=n96 B=n98 A=n103
XU331 OAI21XL $PINS Y=n58 B0=n60 A1=n59 A0=n87
XU332 AOI21X1 $PINS Y=n60 B0=n62 A1=n61 A0=n74
XU333 CLKINVX1 $PINS Y=n105 A=n106
XU334 AOI21X1 $PINS Y=n135 B0=n137 A1=n136 A0=n149
XU335 OAI21XL $PINS Y=n137 B0=n139 A1=n144 A0=n138
XU336 NAND2XL $PINS Y=n22 B=n154 A=n212
XU337 NOR2X1 $PINS Y=n136 B=n138 A=n143
XU338 XNOR2X1 $PINS Y=SUM[21] B=n11 A=n92
XU339 XNOR2X1 $PINS Y=SUM[30] B=n2 A=n38
XU340 AOI21X1 $PINS Y=n33 B0=n35 A1=n34 A0=n38
XU341 NAND2X1 $PINS Y=n38 B=n40 A=n367
XU342 NOR2X1 $PINS Y=n180 B=A[5] A=n337
XU344 INVXL $PINS Y=n116 A=n118
XU345 INVXL $PINS Y=n199 A=n75
XU346 NOR2X1 $PINS Y=n73 B=n75 A=n80
XU347 NOR2X1 $PINS Y=n75 B=A[23] A=B[23]
XU348 NOR2X1 $PINS Y=n61 B=n63 A=n68
XU349 NOR2X1 $PINS Y=n68 B=A[24] A=B[24]
XU350 NOR2X1 $PINS Y=n63 B=A[25] A=B[25]
XU351 CLKBUFX3 $PINS Y=n335 A=B[4]
XU353 CLKBUFX3 $PINS Y=n337 A=B[5]
XU355 NAND2X1 $PINS Y=n341 B=n340 A=n339
XU356 NAND2X1 $PINS Y=n149 B=n151 A=n341
XU357 NAND2XL $PINS Y=n151 B=A[11] A=B[11]
XU358 INVX1 $PINS Y=n155 A=n156
XU359 INVXL $PINS Y=n146 A=n148
XU360 XNOR2X1 $PINS Y=SUM[12] B=n20 A=n145
XU361 NAND2X1 $PINS Y=n70 B=n72 A=n369
XU362 NAND2X1 $PINS Y=n369 B=n368 A=n327
XU363 INVXL $PINS Y=n346 A=n135
XU364 OR2X1 $PINS Y=n133 B=n346 A=n345
XU365 NAND2X1 $PINS Y=n134 B=n136 A=n148
XU366 CLKINVX1 $PINS Y=n132 A=n133
XU368 NAND2X1 $PINS Y=n46 B=n48 A=n362
XU369 AO21X1 $PINS Y=n365 B0=n102 A1=n101 A0=n105
XU370 AND2X2 $PINS Y=n355 B=n107 A=n156
XU371 NOR2X1 $PINS Y=n107 B=n109 A=n134
XU372 INVXL $PINS Y=n176 A=n177
XU373 CLKINVX1 $PINS Y=n351 A=n8
XU374 INVXL $PINS Y=n350 A=n70
XU375 NAND2XL $PINS Y=n352 B=n8 A=n70
XU376 NAND2X1 $PINS Y=n69 B=A[24] A=B[24]
XU377 NAND2X1 $PINS Y=n144 B=A[12] A=B[12]
XU378 NOR2X1 $PINS Y=n143 B=A[12] A=B[12]
XU379 NAND2X1 $PINS Y=n170 B=A[7] A=B[7]
XU380 AND2XL $PINS Y=n348 B=n111 A=n124
XU381 NOR2X1 $PINS Y=n169 B=A[7] A=B[7]
XU382 NAND2X1 $PINS Y=n165 B=A[8] A=B[8]
XU383 NAND2X1 $PINS Y=n353 B=n351 A=n350
XU384 NAND2X1 $PINS Y=SUM[24] B=n353 A=n352
XU385 NAND2XL $PINS Y=n8 B=n69 A=n198
XU386 OR2X1 $PINS Y=n97 B=n361 A=n360
XU387 CLKINVX1 $PINS Y=n361 A=n99
XU388 AND2X2 $PINS Y=n354 B=n88 A=n97
XU389 NOR2X1 $PINS Y=n164 B=A[8] A=B[8]
XU390 OAI21XL $PINS Y=n156 B0=n158 A1=n157 A0=n177
XU391 NAND2X1 $PINS Y=n119 B=A[16] A=B[16]
XU392 NAND2X1 $PINS Y=n55 B=A[26] A=n326
XU394 INVXL $PINS Y=n84 A=n86
XU396 XOR2X1 $PINS Y=SUM[20] B=n12 A=n95
XU397 INVXL $PINS Y=n202 A=n93
XU398 OR2X1 $PINS Y=n362 B=n47 A=n106
XU399 NOR2X1 $PINS Y=n138 B=A[13] A=B[13]
XU400 NOR2X1 $PINS Y=n113 B=A[17] A=B[17]
XU401 NAND2X1 $PINS Y=n94 B=A[20] A=B[20]
XU402 NAND2XL $PINS Y=n40 B=A[29] A=B[29]
XU403 NAND2X1 $PINS Y=n59 B=n61 A=n73
XU404 NAND2X1 $PINS Y=n47 B=n49 A=n57
XU405 NAND2XL $PINS Y=n4 B=n45 A=n328
XU406 XNOR2XL $PINS Y=SUM[28] B=n4 A=n46
XU407 NAND2X1 $PINS Y=n131 B=A[14] A=B[14]
XU408 NAND2X1 $PINS Y=n104 B=A[18] A=B[18]
XU409 NOR2X1 $PINS Y=n103 B=A[18] A=B[18]
XU410 NOR2X1 $PINS Y=n54 B=A[26] A=n326
XU411 NOR2X1 $PINS Y=n51 B=A[27] A=B[27]
XU412 NOR2X1 $PINS Y=n187 B=A[3] A=B[3]
XU413 NAND2X1 $PINS Y=n157 B=n159 A=n167
XU414 XOR2X1 $PINS Y=SUM[4] B=n28 A=n185
XU415 INVXL $PINS Y=n218 A=n183
XU416 OAI21XL $PINS Y=n182 B0=n184 A1=n183 A0=n185
XU417 AOI21X1 $PINS Y=n41 B0=n43 A1=n328 A0=n46
XU418 CLKINVX1 $PINS Y=n43 A=n45
XU419 NAND2BXL $PINS Y=n30 B=n190 AN=n189
XU420 INVX1 $PINS Y=SUM[2] A=n30
XU421 NOR2X1 $PINS Y=n150 B=A[11] A=B[11]
XU422 INVXL $PINS Y=n359 A=n170
XU423 NOR2X1 $PINS Y=n360 B=n98 A=n104
XU424 NAND2X1 $PINS Y=n99 B=B[19] A=A[19]
XU425 INVXL $PINS Y=n147 A=n149
XU427 INVXL $PINS Y=n185 A=n186
XU428 CLKINVX1 $PINS Y=n368 A=n71
XU430 XNOR2X1 $PINS Y=SUM[13] B=n19 A=n363
XU431 XOR2X1 $PINS Y=SUM[27] B=n5 A=n364
XU432 XNOR2X1 $PINS Y=SUM[19] B=n13 A=n365
XU433 OAI21XL $PINS Y=n163 B0=n165 A1=n164 A0=n166
XU434 XNOR2X1 $PINS Y=SUM[7] B=n25 A=n366
XU435 AO21XL $PINS Y=n366 B0=n173 A1=n172 A0=n176
XU436 INVXL $PINS Y=n35 A=n37
XU438 NOR2X1 $PINS Y=n123 B=n125 A=n130
XU440 NAND2XL $PINS Y=n139 B=A[13] A=B[13]
XU441 NAND2XL $PINS Y=n162 B=A[9] A=B[9]
XU442 NAND2XL $PINS Y=n91 B=A[21] A=B[21]
XU443 NAND2XL $PINS Y=n114 B=A[17] A=B[17]
XU444 NAND2XL $PINS Y=n52 B=A[27] A=B[27]
XU445 NOR2XL $PINS Y=n189 B=A[2] A=B[2]
XU446 NOR2X1 $PINS Y=n36 B=A[30] A=B[30]
XU447 INVXL $PINS Y=n71 A=n73
XU448 INVX1 $PINS Y=n72 A=n74
XU449 AOI21X1 $PINS Y=n166 B0=n168 A1=n167 A0=n176
XU450 NAND2X1 $PINS Y=n86 B=n88 A=n96
XU451 OAI21XL $PINS Y=n62 B0=n64 A1=n69 A0=n63
XU452 AOI21X1 $PINS Y=n48 B0=n50 A1=n49 A0=n58
XU453 NOR2X1 $PINS Y=n49 B=n51 A=n54
XU454 XNOR2X1 $PINS Y=SUM[6] B=n26 A=n176
XU455 NAND2X1 $PINS Y=n26 B=n175 A=n172
XU456 NAND2X1 $PINS Y=n5 B=n52 A=n195
XU457 OAI21XL $PINS Y=n50 B0=n52 A1=n55 A0=n51
XU458 XNOR2X1 $PINS Y=SUM[5] B=n27 A=n182
XU459 NAND2X1 $PINS Y=n27 B=n181 A=n217
XU460 XNOR2X1 $PINS Y=SUM[9] B=n23 A=n163
XU461 NAND2X1 $PINS Y=n23 B=n162 A=n213
XU462 XNOR2X1 $PINS Y=SUM[11] B=n21 A=n152
XU463 NAND2X1 $PINS Y=n21 B=n151 A=n339
XU464 NAND2X1 $PINS Y=n11 B=n91 A=n201
XU465 XOR2X1 $PINS Y=SUM[29] B=n3 A=n41
XU466 NAND2X1 $PINS Y=n3 B=n40 A=n1
XU467 XNOR2X1 $PINS Y=SUM[16] B=n16 A=n120
XU468 NAND2X1 $PINS Y=n16 B=n119 A=n116
XU470 NAND2X1 $PINS Y=n15 B=n114 A=n205
XU472 NAND2X1 $PINS Y=n14 B=n104 A=n101
XU473 NAND2X1 $PINS Y=n13 B=n99 A=n203
XU474 NAND2X1 $PINS Y=n12 B=n94 A=n202
XU475 XNOR2X1 $PINS Y=SUM[22] B=n10 A=n327
XU476 NAND2X1 $PINS Y=n10 B=n81 A=n78
XU477 XOR2X1 $PINS Y=SUM[23] B=n9 A=n77
XU478 NAND2X1 $PINS Y=n9 B=n76 A=n199
XU479 AOI21X1 $PINS Y=n77 B0=n79 A1=n78 A0=n327
XU480 CLKINVX1 $PINS Y=n198 A=n68
XU481 XOR2X1 $PINS Y=SUM[8] B=n24 A=n166
XU482 NAND2X1 $PINS Y=n24 B=n165 A=n214
XU483 CLKINVX1 $PINS Y=n214 A=n164
XU484 XOR2X1 $PINS Y=SUM[10] B=n22 A=n155
XU485 NAND2X1 $PINS Y=n20 B=n144 A=n141
XU486 XOR2X1 $PINS Y=SUM[14] B=n18 A=n132
XU487 NAND2X1 $PINS Y=n18 B=n131 A=n128
XU488 NAND2BX1 $PINS Y=n2 B=n37 AN=n36
XU489 CLKINVX1 $PINS Y=n172 A=n174
XU490 CLKINVX1 $PINS Y=n141 A=n143
XU491 CLKINVX1 $PINS Y=n128 A=n130
XU492 CLKINVX1 $PINS Y=n78 A=n80
XU493 CLKINVX1 $PINS Y=n34 A=n36
XU494 CLKINVX1 $PINS Y=n67 A=n69
XU495 NAND2X1 $PINS Y=n25 B=n170 A=n215
XU496 NAND2X1 $PINS Y=n28 B=n184 A=n218
XU497 NAND2X1 $PINS Y=n19 B=n139 A=n209
XU498 XOR2X1 $PINS Y=SUM[15] B=n17 A=n127
XU500 NAND2X1 $PINS Y=n7 B=n64 A=n197
XU501 CLKINVX1 $PINS Y=n197 A=n63
XU502 NAND2X1 $PINS Y=n6 B=n55 A=n196
XU503 CLKINVX1 $PINS Y=n196 A=n54
XU504 XOR2X1 $PINS Y=SUM[3] B=n190 A=n29
XU505 NAND2X1 $PINS Y=n29 B=n188 A=n219
XU506 CLKINVX1 $PINS Y=n219 A=n187
XU507 CLKINVX1 $PINS Y=n173 A=n175
XU508 CLKINVX1 $PINS Y=n142 A=n144
XU509 CLKINVX1 $PINS Y=n129 A=n131
XU510 CLKINVX1 $PINS Y=n117 A=n119
XU511 CLKINVX1 $PINS Y=n102 A=n104
XU512 CLKINVX1 $PINS Y=n79 A=n81
XU513 CLKINVX1 $PINS Y=n195 A=n51
XU514 CLKINVX1 $PINS Y=n217 A=n180
XU515 CLKINVX1 $PINS Y=n215 A=n169
XU516 CLKINVX1 $PINS Y=n213 A=n161
XU517 CLKINVX1 $PINS Y=n209 A=n138
XU518 CLKINVX1 $PINS Y=n207 A=n125
XU519 CLKINVX1 $PINS Y=n205 A=n113
XU520 CLKINVX1 $PINS Y=n203 A=n98
XU521 CLKINVX1 $PINS Y=n201 A=n90
XU522 OR2X1 $PINS Y=n370 B=A[31] A=B[31]
XU523 NAND2X1 $PINS Y=n37 B=A[30] A=B[30]
XU524 NAND2X1 $PINS Y=n45 B=A[28] A=B[28]
XU525 NAND2X1 $PINS Y=n188 B=A[3] A=B[3]
XU528 NAND2X1 $PINS Y=n32 B=A[31] A=B[31]
XU529 CLKBUFX3 $PINS Y=SUM[1] A=A[1]
XU530 CLKBUFX3 $PINS Y=SUM[0] A=A[0]
XU1 INVXL $PINS Y=n1 A=n65
XU2 OAI2BB1X1 $PINS Y=n92 B0=n94 A1N=n202 A0N=n31
XU3 INVX1 $PINS Y=n31 A=n95
XU4 OA21XL $PINS Y=n39 B0=n154 A1=n153 A0=n155
XU5 INVX1 $PINS Y=n152 A=n39
XU6 OAI2BB1X1 $PINS Y=n327 B0=n87 A1N=n84 A0N=n105
XU7 XNOR2X1 $PINS Y=SUM[17] B=n15 A=n42
XU8 AO21X1 $PINS Y=n42 B0=n117 A1=n116 A0=n120
XU9 NOR2BX1 $PINS Y=n95 B=n97 AN=n44
XU10 NAND2X1 $PINS Y=n44 B=n96 A=n105
XU11 AO21X1 $PINS Y=n53 B0=n58 A1=n57 A0=n105
XU12 INVX1 $PINS Y=n56 A=n53
XU13 OR2X1 $PINS Y=n367 B=n65 A=n41
XU14 INVX1 $PINS Y=n65 A=n329
XU17 XNOR2X1 $PINS Y=SUM[31] B=n83 A=n33
XU18 AND2X2 $PINS Y=n83 B=n32 A=n370
XU19 XNOR2X1 $PINS Y=SUM[25] B=n7 A=n85
XU20 AO21X1 $PINS Y=n85 B0=n67 A1=n198 A0=n70
XU21 NOR2BX1 $PINS Y=n100 B=n4586 AN=n337
XU22 INVX1 $PINS Y=n181 A=n100
.ENDS

.SUBCKT InstructionDecode_test_1 clk rst stall PCadd4[31] PCadd4[30] PCadd4[29]
+ PCadd4[28] PCadd4[27] PCadd4[26] PCadd4[25] PCadd4[24] PCadd4[23] PCadd4[22]
+ PCadd4[21] PCadd4[20] PCadd4[19] PCadd4[18] PCadd4[17] PCadd4[16] PCadd4[15]
+ PCadd4[14] PCadd4[13] PCadd4[12] PCadd4[11] PCadd4[10] PCadd4[9] PCadd4[8]
+ PCadd4[7] PCadd4[6] PCadd4[5] PCadd4[4] PCadd4[3] PCadd4[2] PCadd4[1]
+ PCadd4[0] Instruction[31] Instruction[30] Instruction[29] Instruction[28]
+ Instruction[27] Instruction[26] Instruction[25] Instruction[24]
+ Instruction[23] Instruction[22] Instruction[21] Instruction[20]
+ Instruction[19] Instruction[18] Instruction[17] Instruction[16]
+ Instruction[15] Instruction[14] Instruction[13] Instruction[12]
+ Instruction[11] Instruction[10] Instruction[9] Instruction[8] Instruction[7]
+ Instruction[6] Instruction[5] Instruction[4] Instruction[3] Instruction[2]
+ Instruction[1] Instruction[0] PCbranched[31] PCbranched[30] PCbranched[29]
+ PCbranched[28] PCbranched[27] PCbranched[26] PCbranched[25] PCbranched[24]
+ PCbranched[23] PCbranched[22] PCbranched[21] PCbranched[20] PCbranched[19]
+ PCbranched[18] PCbranched[17] PCbranched[16] PCbranched[15] PCbranched[14]
+ PCbranched[13] PCbranched[12] PCbranched[11] PCbranched[10] PCbranched[9]
+ PCbranched[8] PCbranched[7] PCbranched[6] PCbranched[5] PCbranched[4]
+ PCbranched[3] PCbranched[2] PCbranched[1] PCbranched[0] Reg_W[4] Reg_W[3]
+ Reg_W[2] Reg_W[1] Reg_W[0] WriteData[31] WriteData[30] WriteData[29]
+ WriteData[28] WriteData[27] WriteData[26] WriteData[25] WriteData[24]
+ WriteData[23] WriteData[22] WriteData[21] WriteData[20] WriteData[19]
+ WriteData[18] WriteData[17] WriteData[16] WriteData[15] WriteData[14]
+ WriteData[13] WriteData[12] WriteData[11] WriteData[10] WriteData[9]
+ WriteData[8] WriteData[7] WriteData[6] WriteData[5] WriteData[4] WriteData[3]
+ WriteData[2] WriteData[1] WriteData[0] WB[1] WB[0] MEM[2] MEM[1] MEM[0] EX[6]
+ EX[5] EX[4] EX[3] EX[2] EX[1] EX[0] RData1[31] RData1[30] RData1[29]
+ RData1[28] RData1[27] RData1[26] RData1[25] RData1[24] RData1[23] RData1[22]
+ RData1[21] RData1[20] RData1[19] RData1[18] RData1[17] RData1[16] RData1[15]
+ RData1[14] RData1[13] RData1[12] RData1[11] RData1[10] RData1[9] RData1[8]
+ RData1[7] RData1[6] RData1[5] RData1[4] RData1[3] RData1[2] RData1[1]
+ RData1[0] RData2[31] RData2[30] RData2[29] RData2[28] RData2[27] RData2[26]
+ RData2[25] RData2[24] RData2[23] RData2[22] RData2[21] RData2[20] RData2[19]
+ RData2[18] RData2[17] RData2[16] RData2[15] RData2[14] RData2[13] RData2[12]
+ RData2[11] RData2[10] RData2[9] RData2[8] RData2[7] RData2[6] RData2[5]
+ RData2[4] RData2[3] RData2[2] RData2[1] RData2[0] next_RData1[31]
+ next_RData1[30] next_RData1[29] next_RData1[28] next_RData1[27]
+ next_RData1[26] next_RData1[25] next_RData1[24] next_RData1[23]
+ next_RData1[22] next_RData1[21] next_RData1[20] next_RData1[19]
+ next_RData1[18] next_RData1[17] next_RData1[16] next_RData1[15]
+ next_RData1[14] next_RData1[13] next_RData1[12] next_RData1[11]
+ next_RData1[10] next_RData1[9] next_RData1[8] next_RData1[7] next_RData1[6]
+ next_RData1[5] next_RData1[4] next_RData1[3] next_RData1[2] next_RData1[1]
+ next_RData1[0] Immediate_SE[31] Immediate_SE[30] Immediate_SE[29]
+ Immediate_SE[28] Immediate_SE[27] Immediate_SE[26] Immediate_SE[25]
+ Immediate_SE[24] Immediate_SE[23] Immediate_SE[22] Immediate_SE[21]
+ Immediate_SE[20] Immediate_SE[19] Immediate_SE[18] Immediate_SE[17]
+ Immediate_SE[16] Immediate_SE[15] Immediate_SE[14] Immediate_SE[13]
+ Immediate_SE[12] Immediate_SE[11] Immediate_SE[10] Immediate_SE[9]
+ Immediate_SE[8] Immediate_SE[7] Immediate_SE[6] Immediate_SE[5]
+ Immediate_SE[4] Immediate_SE[3] Immediate_SE[2] Immediate_SE[1]
+ Immediate_SE[0] RegisterRd[4] RegisterRd[3] RegisterRd[2] RegisterRd[1]
+ RegisterRd[0] RegisterRs[4] RegisterRs[3] RegisterRs[2] RegisterRs[1]
+ RegisterRs[0] RegisterRt[4] RegisterRt[3] RegisterRt[2] RegisterRt[1]
+ RegisterRt[0] MEM_RegWrite RegDst Jump Branch MemRead MemtoReg MemWrite
+ ALUOp[2] ALUOp[1] ALUOp[0] ALUSrc RegWrite Bubble PCBuffer_valid equal
+ EX_RegWriteData[31] EX_RegWriteData[30] EX_RegWriteData[29]
+ EX_RegWriteData[28] EX_RegWriteData[27] EX_RegWriteData[26]
+ EX_RegWriteData[25] EX_RegWriteData[24] EX_RegWriteData[23]
+ EX_RegWriteData[22] EX_RegWriteData[21] EX_RegWriteData[20]
+ EX_RegWriteData[19] EX_RegWriteData[18] EX_RegWriteData[17]
+ EX_RegWriteData[16] EX_RegWriteData[15] EX_RegWriteData[14]
+ EX_RegWriteData[13] EX_RegWriteData[12] EX_RegWriteData[11]
+ EX_RegWriteData[10] EX_RegWriteData[9] EX_RegWriteData[8] EX_RegWriteData[7]
+ EX_RegWriteData[6] EX_RegWriteData[5] EX_RegWriteData[4] EX_RegWriteData[3]
+ EX_RegWriteData[2] EX_RegWriteData[1] EX_RegWriteData[0] MEM_RegWriteData[31]
+ MEM_RegWriteData[30] MEM_RegWriteData[29] MEM_RegWriteData[28]
+ MEM_RegWriteData[27] MEM_RegWriteData[26] MEM_RegWriteData[25]
+ MEM_RegWriteData[24] MEM_RegWriteData[23] MEM_RegWriteData[22]
+ MEM_RegWriteData[21] MEM_RegWriteData[20] MEM_RegWriteData[19]
+ MEM_RegWriteData[18] MEM_RegWriteData[17] MEM_RegWriteData[16]
+ MEM_RegWriteData[15] MEM_RegWriteData[14] MEM_RegWriteData[13]
+ MEM_RegWriteData[12] MEM_RegWriteData[11] MEM_RegWriteData[10]
+ MEM_RegWriteData[9] MEM_RegWriteData[8] MEM_RegWriteData[7]
+ MEM_RegWriteData[6] MEM_RegWriteData[5] MEM_RegWriteData[4]
+ MEM_RegWriteData[3] MEM_RegWriteData[2] MEM_RegWriteData[1]
+ MEM_RegWriteData[0] BrForwardA[1] BrForwardA[0] BrForwardB[1] BrForwardB[0]
+ PredictMiss BranchTaken test_si2 test_si1 test_so2 test_so1 test_se
+ SPCASCAN_N1 FE_PT1_ICACHE_addr_i_8_ SPCASCAN_N2 FE_PT1_ICACHE_addr_i_9_
+ SPCASCAN_N3 FE_PT1_ICACHE_addr_i_18_ SPCASCAN_N4 FE_PT1_ICACHE_addr_i_31_
+ SPCASCAN_N5 SPCASCAN_N6 SPCASCAN_N7 SPCASCAN_N8 SPCASCAN_N12
+ FE_PT1_ICACHE_addr_i_26_ SPCASCAN_N13 SPCASCAN_N14 SPCASCAN_N15 SPCASCAN_N16
+ SPCASCAN_N17 SPCASCAN_N18 SPCASCAN_N19 SPCASCAN_N20 SPCASCAN_N21 SPCASCAN_N22
+ FE_PT1_ICACHE_addr_i_30_ SPCASCAN_N23 SPCASCAN_N24 SPCASCAN_N25
+ FE_PT1_ICACHE_addr_i_3_ SPCASCAN_N26 FE_PT1_ICACHE_addr_i_7_ SPCASCAN_N27
+ FE_PT1_ICACHE_addr_i_6_ SPCASCAN_N28 FE_PT1_ICACHE_addr_i_5_ SPCASCAN_N29
+ SPCASCAN_N30 SPCASCAN_N31 SPCASCAN_N32 SPCASCAN_N33 SPCASCAN_N34 SPCASCAN_N35
+ SPCASCAN_N36 SPCASCAN_N37 FE_PT1_ICACHE_addr_i_17_ FE_OFN0_test_se_i
+ FE_OFN13_test_se_i FE_OFN14_test_se_i FE_OFN15_test_se_i FE_OFN18_test_se_i
+ FE_OFN1_test_se_i FE_OFN20_test_se_i FE_OFN21_test_se_i FE_OFN23_test_se_i
+ FE_OFN4_test_se_i FE_OFN5_test_se_i FE_OFN7_test_se_i FE_OFN8_test_se_i
+ FE_PT1_n337 FE_PT1_n336 SPCBSCAN_N38 SPCBSCAN_N39 SPCBSCAN_N40 SPCBSCAN_N41
+ SPCBSCAN_N42 FE_OFN53_test_se_i FE_OFN54_test_se_i FE_OFN74_test_se_i
+ FE_OFN75_test_se_i FE_OFN93_test_se_i FE_OFN94_test_se_i FE_OFN96_test_se_i
+ FE_OFN97_test_se_i FE_OFN100_test_se_i FE_OFN101_test_se_i FE_OFN99_test_se_i
+ FE_OFN102_test_se_i FE_OFN105_test_se_i FE_OFN106_test_se_i
+ FE_OFN108_test_se_i FE_OFN109_test_se_i FE_OFN110_test_se_i
+ FE_OFN113_test_se_i FE_OFN114_test_se_i FE_OFN116_test_se_i clk_i__L3_N1
+ clk_i__L3_N10 clk_i__L3_N11 clk_i__L3_N12 clk_i__L3_N13 clk_i__L3_N14
+ clk_i__L3_N15 clk_i__L3_N16 clk_i__L3_N17 clk_i__L3_N18 clk_i__L3_N19
+ clk_i__L3_N2 clk_i__L3_N20 clk_i__L3_N21 clk_i__L3_N22 clk_i__L3_N23
+ clk_i__L3_N24 clk_i__L3_N25 clk_i__L3_N26 clk_i__L3_N27 clk_i__L3_N3
+ clk_i__L3_N4 clk_i__L3_N5 clk_i__L3_N6 clk_i__L3_N7 clk_i__L3_N8 clk_i__L3_N9
*.CONNECT MEM[2] VSS
*.CONNECT N17 Instruction[21]
*.CONNECT N18 Instruction[22]
*.CONNECT N19 Instruction[23]
*.CONNECT N20 Instruction[24]
*.CONNECT N21 Instruction[25]
*.CONNECT N22 Instruction[16]
*.CONNECT N23 Instruction[17]
*.CONNECT N24 Instruction[18]
*.CONNECT N25 Instruction[19]
*.CONNECT N26 Instruction[20]
*.CONNECT test_so1 n569
XLTIE_LTIEHI_99 TIEHI $PINS Y=LTIE_LTIEHI_99_NET
XLTIE_LTIEHI_98 TIEHI $PINS Y=LTIE_LTIEHI_98_NET
XLTIE_LTIEHI_97 TIEHI $PINS Y=LTIE_LTIEHI_97_NET
XLTIE_LTIEHI_96 TIEHI $PINS Y=LTIE_LTIEHI_96_NET
XLTIE_LTIEHI_95 TIEHI $PINS Y=LTIE_LTIEHI_95_NET
XLTIE_LTIEHI_94 TIEHI $PINS Y=LTIE_LTIEHI_94_NET
XLTIE_LTIEHI_93 TIEHI $PINS Y=LTIE_LTIEHI_93_NET
XLTIE_LTIEHI_92 TIEHI $PINS Y=LTIE_LTIEHI_92_NET
XLTIE_LTIEHI_91 TIEHI $PINS Y=LTIE_LTIEHI_91_NET
XLTIE_LTIEHI_90 TIEHI $PINS Y=LTIE_LTIEHI_90_NET
XLTIE_LTIEHI_89 TIEHI $PINS Y=LTIE_LTIEHI_89_NET
XLTIE_LTIEHI_88 TIEHI $PINS Y=LTIE_LTIEHI_88_NET
XLTIE_LTIEHI_87 TIEHI $PINS Y=LTIE_LTIEHI_87_NET
XLTIE_LTIEHI_86 TIEHI $PINS Y=LTIE_LTIEHI_86_NET
XLTIE_LTIEHI_85 TIEHI $PINS Y=LTIE_LTIEHI_85_NET
XLTIE_LTIEHI_84 TIEHI $PINS Y=LTIE_LTIEHI_84_NET
XLTIE_LTIEHI_83 TIEHI $PINS Y=LTIE_LTIEHI_83_NET
XLTIE_LTIEHI_82 TIEHI $PINS Y=LTIE_LTIEHI_82_NET
XLTIE_LTIEHI_81 TIEHI $PINS Y=LTIE_LTIEHI_81_NET
XLTIE_LTIEHI_80 TIEHI $PINS Y=LTIE_LTIEHI_80_NET
XLTIE_LTIEHI_79 TIEHI $PINS Y=LTIE_LTIEHI_79_NET
XLTIE_LTIEHI_78 TIEHI $PINS Y=LTIE_LTIEHI_78_NET
XLTIE_LTIEHI_77 TIEHI $PINS Y=LTIE_LTIEHI_77_NET
XLTIE_LTIEHI_76 TIEHI $PINS Y=LTIE_LTIEHI_76_NET
XLTIE_LTIEHI_75 TIEHI $PINS Y=LTIE_LTIEHI_75_NET
XLTIE_LTIEHI_74 TIEHI $PINS Y=LTIE_LTIEHI_74_NET
XLTIE_LTIEHI_73 TIEHI $PINS Y=LTIE_LTIEHI_73_NET
XLTIE_LTIEHI_72 TIEHI $PINS Y=LTIE_LTIEHI_72_NET
XLTIE_LTIEHI_71 TIEHI $PINS Y=LTIE_LTIEHI_71_NET
XLTIE_LTIEHI_70 TIEHI $PINS Y=LTIE_LTIEHI_70_NET
XLTIE_LTIEHI_69 TIEHI $PINS Y=LTIE_LTIEHI_69_NET
XLTIE_LTIEHI_68 TIEHI $PINS Y=LTIE_LTIEHI_68_NET
XLTIE_LTIEHI_67 TIEHI $PINS Y=LTIE_LTIEHI_67_NET
XLTIE_LTIEHI_66 TIEHI $PINS Y=LTIE_LTIEHI_66_NET
XLTIE_LTIEHI_65 TIEHI $PINS Y=LTIE_LTIEHI_65_NET
XLTIE_LTIEHI_64 TIEHI $PINS Y=LTIE_LTIEHI_64_NET
XLTIE_LTIEHI_63 TIEHI $PINS Y=LTIE_LTIEHI_63_NET
XLTIE_LTIEHI_62 TIEHI $PINS Y=LTIE_LTIEHI_62_NET
XLTIE_LTIEHI_61 TIEHI $PINS Y=LTIE_LTIEHI_61_NET
XLTIE_LTIEHI_60 TIEHI $PINS Y=LTIE_LTIEHI_60_NET
XLTIE_LTIEHI_59 TIEHI $PINS Y=LTIE_LTIEHI_59_NET
XLTIE_LTIEHI_58 TIEHI $PINS Y=LTIE_LTIEHI_58_NET
XLTIE_LTIEHI_57 TIEHI $PINS Y=LTIE_LTIEHI_57_NET
XLTIE_LTIEHI_56 TIEHI $PINS Y=LTIE_LTIEHI_56_NET
XLTIE_LTIEHI_55 TIEHI $PINS Y=LTIE_LTIEHI_55_NET
XLTIE_LTIEHI_54 TIEHI $PINS Y=LTIE_LTIEHI_54_NET
XLTIE_LTIEHI_53 TIEHI $PINS Y=LTIE_LTIEHI_53_NET
XLTIE_LTIEHI_52 TIEHI $PINS Y=LTIE_LTIEHI_52_NET
XLTIE_LTIEHI_51 TIEHI $PINS Y=LTIE_LTIEHI_51_NET
XLTIE_LTIEHI_50 TIEHI $PINS Y=LTIE_LTIEHI_50_NET
XLTIE_LTIEHI_49 TIEHI $PINS Y=LTIE_LTIEHI_49_NET
XLTIE_LTIEHI_48 TIEHI $PINS Y=LTIE_LTIEHI_48_NET
XLTIE_LTIEHI_47 TIEHI $PINS Y=LTIE_LTIEHI_47_NET
XLTIE_LTIEHI_46 TIEHI $PINS Y=LTIE_LTIEHI_46_NET
XLTIE_LTIEHI_45 TIEHI $PINS Y=LTIE_LTIEHI_45_NET
XLTIE_LTIEHI_44 TIEHI $PINS Y=LTIE_LTIEHI_44_NET
XLTIE_LTIEHI_43 TIEHI $PINS Y=LTIE_LTIEHI_43_NET
XLTIE_LTIEHI_42 TIEHI $PINS Y=LTIE_LTIEHI_42_NET
XLTIE_LTIEHI_41 TIEHI $PINS Y=LTIE_LTIEHI_41_NET
XLTIE_LTIEHI_40 TIEHI $PINS Y=LTIE_LTIEHI_40_NET
XLTIE_LTIEHI_39 TIEHI $PINS Y=LTIE_LTIEHI_39_NET
XLTIE_LTIEHI_38 TIEHI $PINS Y=LTIE_LTIEHI_38_NET
XLTIE_LTIEHI_37 TIEHI $PINS Y=LTIE_LTIEHI_37_NET
XLTIE_LTIEHI_36 TIEHI $PINS Y=LTIE_LTIEHI_36_NET
XLTIE_LTIEHI_35 TIEHI $PINS Y=LTIE_LTIEHI_35_NET
XLTIE_LTIEHI_34 TIEHI $PINS Y=LTIE_LTIEHI_34_NET
XLTIE_LTIEHI_33 TIEHI $PINS Y=LTIE_LTIEHI_33_NET
XLTIE_LTIEHI_32 TIEHI $PINS Y=LTIE_LTIEHI_32_NET
XLTIE_LTIEHI_31 TIEHI $PINS Y=LTIE_LTIEHI_31_NET
XLTIE_LTIEHI_30 TIEHI $PINS Y=LTIE_LTIEHI_30_NET
XLTIE_LTIEHI_29 TIEHI $PINS Y=LTIE_LTIEHI_29_NET
XLTIE_LTIEHI_28 TIEHI $PINS Y=LTIE_LTIEHI_28_NET
XLTIE_LTIEHI_27 TIEHI $PINS Y=LTIE_LTIEHI_27_NET
XLTIE_LTIEHI_26 TIEHI $PINS Y=LTIE_LTIEHI_26_NET
XLTIE_LTIEHI_25 TIEHI $PINS Y=LTIE_LTIEHI_25_NET
XLTIE_LTIEHI_24 TIEHI $PINS Y=LTIE_LTIEHI_24_NET
XLTIE_LTIEHI_23 TIEHI $PINS Y=LTIE_LTIEHI_23_NET
XLTIE_LTIEHI_22 TIEHI $PINS Y=LTIE_LTIEHI_22_NET
XLTIE_LTIEHI_21 TIEHI $PINS Y=LTIE_LTIEHI_21_NET
XLTIE_LTIEHI_20 TIEHI $PINS Y=LTIE_LTIEHI_20_NET
XLTIE_LTIEHI_19 TIEHI $PINS Y=LTIE_LTIEHI_19_NET
XLTIE_LTIEHI_18 TIEHI $PINS Y=LTIE_LTIEHI_18_NET
XLTIE_LTIEHI_17 TIEHI $PINS Y=LTIE_LTIEHI_17_NET
XLTIE_LTIEHI_16 TIEHI $PINS Y=LTIE_LTIEHI_16_NET
XLTIE_LTIEHI_15 TIEHI $PINS Y=LTIE_LTIEHI_15_NET
XLTIE_LTIEHI_14 TIEHI $PINS Y=LTIE_LTIEHI_14_NET
XLTIE_LTIEHI_13 TIEHI $PINS Y=LTIE_LTIEHI_13_NET
XLTIE_LTIEHI_12 TIEHI $PINS Y=LTIE_LTIEHI_12_NET
XLTIE_LTIEHI_11 TIEHI $PINS Y=LTIE_LTIEHI_11_NET
XLTIE_LTIEHI_10 TIEHI $PINS Y=LTIE_LTIEHI_10_NET
XLTIE_LTIEHI_9 TIEHI $PINS Y=LTIE_LTIEHI_9_NET
XLTIE_LTIEHI_8 TIEHI $PINS Y=LTIE_LTIEHI_8_NET
XLTIE_LTIEHI_7 TIEHI $PINS Y=LTIE_LTIEHI_7_NET
XLTIE_LTIEHI_6 TIEHI $PINS Y=LTIE_LTIEHI_6_NET
XLTIE_LTIEHI_5 TIEHI $PINS Y=LTIE_LTIEHI_5_NET
XLTIE_LTIEHI_4 TIEHI $PINS Y=LTIE_LTIEHI_4_NET
XLTIE_LTIEHI_3 TIEHI $PINS Y=LTIE_LTIEHI_3_NET
XLTIE_LTIEHI_2 TIEHI $PINS Y=LTIE_LTIEHI_2_NET
XLTIE_LTIEHI_1 TIEHI $PINS Y=LTIE_LTIEHI_1_NET
XLTIE_LTIEHI TIEHI $PINS Y=LTIE_LTIEHI_NET
XFE_OFC222_n3745 CLKBUFX2 $PINS Y=FE_OFN222_n3745 A=n3745
XFE_OFC221_n3744 CLKBUFX2 $PINS Y=FE_OFN221_n3744 A=n3744
XFE_OFC220_n3747 CLKBUFX2 $PINS Y=FE_OFN220_n3747 A=n3747
XFE_OFC219_n3749 CLKBUFX2 $PINS Y=FE_OFN219_n3749 A=n3749
XFE_OFC218_n3743 CLKBUFX3 $PINS Y=FE_OFN218_n3743 A=n3741
XFE_OFC217_n3742 CLKBUFX3 $PINS Y=FE_OFN217_n3742 A=n3742
XFE_OFC216_n4267 CLKBUFX3 $PINS Y=FE_OFN216_n4267 A=n4267
XFE_OFC215_n4272 CLKBUFX3 $PINS Y=FE_OFN215_n4272 A=n4272
XFE_OFC214_n4273 CLKBUFX2 $PINS Y=FE_OFN214_n4273 A=n4273
XFE_OFC213_n4271 CLKBUFX2 $PINS Y=FE_OFN213_n4271 A=n4271
XFE_OFC204_n4420 CLKBUFX2 $PINS Y=FE_OFN204_n4420 A=n4420
XFE_OFC202_n4357 CLKBUFX2 $PINS Y=FE_OFN202_n4357 A=n4357
XFE_OFC201_n4349 CLKBUFX2 $PINS Y=FE_OFN201_n4349 A=n4349
XFE_OFC200_n4341 CLKBUFX2 $PINS Y=FE_OFN200_n4341 A=n4341
XFE_OFC199_n4333 CLKBUFX2 $PINS Y=FE_OFN199_n4333 A=n4333
XFE_OFC198_n4317 CLKBUFX2 $PINS Y=FE_OFN198_n4317 A=n4317
XFE_OFC197_n4351 CLKBUFX2 $PINS Y=FE_OFN197_n4351 A=n4351
XFE_OFC196_n4343 CLKBUFX2 $PINS Y=FE_OFN196_n4343 A=n4343
XFE_OFC195_n4335 CLKBUFX2 $PINS Y=FE_OFN195_n4335 A=n4335
XFE_OFC194_n4359 CLKBUFX2 $PINS Y=FE_OFN194_n4359 A=n4359
XFE_OFC193_n4303 CLKBUFX2 $PINS Y=FE_OFN193_n4303 A=n4303
XFE_OFC192_n4353 CLKBUFX2 $PINS Y=FE_OFN192_n4353 A=n131
XFE_OFC191_n4345 CLKBUFX2 $PINS Y=FE_OFN191_n4345 A=n4345
XFE_OFC190_n4337 CLKBUFX2 $PINS Y=FE_OFN190_n4337 A=n4337
XFE_OFC189_n4361 CLKBUFX2 $PINS Y=FE_OFN189_n4361 A=n4361
XFE_OFC188_n4355 CLKBUFX2 $PINS Y=FE_OFN188_n4355 A=n4355
XFE_OFC187_n4347 CLKBUFX2 $PINS Y=FE_OFN187_n4347 A=n4347
XFE_OFC186_n4339 CLKBUFX2 $PINS Y=FE_OFN186_n4339 A=n4339
XFE_OFC185_n4331 CLKBUFX2 $PINS Y=FE_OFN185_n4331 A=n4331
XFE_OFC184_n4307 CLKBUFX2 $PINS Y=FE_OFN184_n4307 A=n4307
XFE_OFC183_n4417 CLKBUFX2 $PINS Y=FE_OFN183_n4417 A=n4417
XFE_OFC182_n1793 CLKBUFX2 $PINS Y=FE_OFN182_n1793 A=n1793
XFE_OFC181_n4367 CLKBUFX2 $PINS Y=FE_OFN181_n4367 A=n4367
XFE_OFC180_n4411 CLKBUFX2 $PINS Y=FE_OFN180_n4411 A=n4411
XFE_OFC179_n4408 CLKBUFX2 $PINS Y=FE_OFN179_n4408 A=n4408
XFE_OFC178_n4402 CLKBUFX2 $PINS Y=FE_OFN178_n4402 A=n4402
XFE_OFC177_n4400 CLKBUFX2 $PINS Y=FE_OFN177_n4400 A=n4400
XFE_OFC164_n4517 CLKBUFX2 $PINS Y=FE_OFN164_n4517 A=n4517
XFE_OFC163_n4451 CLKBUFX2 $PINS Y=FE_OFN163_n4451 A=n4462
XFE_OFC162_n4509 CLKBUFX2 $PINS Y=FE_OFN162_n4509 A=n4509
XFE_OFC161_n4512 CLKBUFX2 $PINS Y=FE_OFN161_n4512 A=n4512
XFE_OFC160_n4513 CLKBUFX2 $PINS Y=FE_OFN160_n4513 A=n4513
XFE_OFC159_n4453 CLKBUFX2 $PINS Y=FE_OFN159_n4453 A=n4453
XFE_OFC158_n4465 CLKBUFX2 $PINS Y=FE_OFN158_n4465 A=n4465
XFE_OFC157_n4472 CLKBUFX2 $PINS Y=FE_OFN157_n4472 A=n4472
XFE_OFC156_n4473 CLKBUFX2 $PINS Y=FE_OFN156_n4473 A=n4473
XFE_OFC155_n4473 CLKBUFX2 $PINS Y=FE_OFN155_n4473 A=n4473
XFE_OFC154_n4476 CLKBUFX2 $PINS Y=FE_OFN154_n4476 A=n4476
XFE_OFC153_n4477 CLKBUFX2 $PINS Y=FE_OFN153_n4477 A=n4477
XFE_OFC152_n4480 CLKBUFX2 $PINS Y=FE_OFN152_n4480 A=n4480
XFE_OFC151_n4481 CLKBUFX2 $PINS Y=FE_OFN151_n4481 A=n4481
XFE_OFC150_n4488 CLKBUFX2 $PINS Y=FE_OFN150_n4488 A=n4488
XFE_OFC149_n4489 CLKBUFX2 $PINS Y=FE_OFN149_n4489 A=n4489
XFE_OFC148_n4462 CLKBUFX2 $PINS Y=FE_OFN148_n4462 A=n4462
XFE_OFC147_n4455 CLKBUFX3 $PINS Y=FE_OFN147_n4455 A=n4457
XFE_OFC146_n4457 CLKBUFX2 $PINS Y=FE_OFN146_n4457 A=n4457
XFE_OFC125_n4445 CLKBUFX2 $PINS Y=FE_OFN125_n4445 A=n4443
XFE_OFC124_n4438 CLKBUFX3 $PINS Y=FE_OFN124_n4438 A=n4438
XFE_OFC115_test_se_i CLKBUFX2 $PINS Y=FE_OFN115_test_se_i A=FE_OFN114_test_se_i
XFE_OFC112_test_se_i CLKBUFX2 $PINS Y=FE_OFN112_test_se_i A=FE_OFN0_test_se_i
XFE_OFC111_test_se_i CLKBUFX2 $PINS Y=FE_OFN111_test_se_i A=FE_OFN0_test_se_i
XFE_OFC92_test_se_i CLKBUFX2 $PINS Y=FE_OFN92_test_se_i A=FE_OFN91_test_se_i
XFE_OFC91_test_se_i CLKBUFX2 $PINS Y=FE_OFN91_test_se_i A=FE_OFN90_test_se_i
XFE_OFC90_test_se_i CLKBUFX2 $PINS Y=FE_OFN90_test_se_i A=FE_OFN12_test_se_i
XFE_OFC89_test_se_i CLKBUFX2 $PINS Y=FE_OFN89_test_se_i A=FE_OFN87_test_se_i
XFE_OFC88_test_se_i CLKBUFX2 $PINS Y=FE_OFN88_test_se_i A=FE_OFN87_test_se_i
XFE_OFC87_test_se_i CLKBUFX2 $PINS Y=FE_OFN87_test_se_i A=FE_OFN9_test_se_i
XFE_OFC86_test_se_i CLKBUFX2 $PINS Y=FE_OFN86_test_se_i A=FE_OFN85_test_se_i
XFE_OFC85_test_se_i CLKBUFX2 $PINS Y=FE_OFN85_test_se_i A=FE_OFN84_test_se_i
XFE_OFC84_test_se_i CLKBUFX2 $PINS Y=FE_OFN84_test_se_i A=FE_OFN11_test_se_i
XFE_OFC83_test_se_i CLKBUFX2 $PINS Y=FE_OFN83_test_se_i A=FE_OFN82_test_se_i
XFE_OFC82_test_se_i CLKBUFX2 $PINS Y=FE_OFN82_test_se_i A=FE_OFN81_test_se_i
XFE_OFC81_test_se_i CLKBUFX2 $PINS Y=FE_OFN81_test_se_i A=FE_OFN11_test_se_i
XFE_OFC80_test_se_i CLKBUFX2 $PINS Y=FE_OFN80_test_se_i A=FE_OFN78_test_se_i
XFE_OFC79_test_se_i CLKBUFX2 $PINS Y=FE_OFN79_test_se_i A=FE_OFN12_test_se_i
XFE_OFC78_test_se_i CLKBUFX2 $PINS Y=FE_OFN78_test_se_i A=FE_OFN12_test_se_i
XFE_OFC77_test_se_i CLKBUFX2 $PINS Y=FE_OFN77_test_se_i A=FE_OFN76_test_se_i
XFE_OFC76_test_se_i CLKBUFX2 $PINS Y=FE_OFN76_test_se_i A=FE_OFN1_test_se_i
XFE_OFC73_test_se_i CLKBUFX2 $PINS Y=FE_OFN73_test_se_i A=FE_OFN18_test_se_i
XFE_OFC72_test_se_i CLKBUFX2 $PINS Y=FE_OFN72_test_se_i A=FE_OFN18_test_se_i
XFE_OFC71_test_se_i CLKBUFX2 $PINS Y=FE_OFN71_test_se_i A=FE_OFN70_test_se_i
XFE_OFC70_test_se_i CLKBUFX2 $PINS Y=FE_OFN70_test_se_i A=FE_OFN69_test_se_i
XFE_OFC69_test_se_i CLKBUFX2 $PINS Y=FE_OFN69_test_se_i A=FE_OFN22_test_se_i
XFE_OFC68_test_se_i CLKBUFX2 $PINS Y=FE_OFN68_test_se_i A=FE_OFN67_test_se_i
XFE_OFC67_test_se_i CLKBUFX2 $PINS Y=FE_OFN67_test_se_i A=FE_OFN66_test_se_i
XFE_OFC66_test_se_i CLKBUFX2 $PINS Y=FE_OFN66_test_se_i A=FE_OFN17_test_se_i
XFE_OFC65_test_se_i CLKBUFX2 $PINS Y=FE_OFN65_test_se_i A=FE_OFN64_test_se_i
XFE_OFC64_test_se_i CLKBUFX2 $PINS Y=FE_OFN64_test_se_i A=FE_OFN63_test_se_i
XFE_OFC63_test_se_i CLKBUFX2 $PINS Y=FE_OFN63_test_se_i A=FE_OFN17_test_se_i
XFE_OFC62_test_se_i CLKBUFX2 $PINS Y=FE_OFN62_test_se_i A=FE_OFN61_test_se_i
XFE_OFC61_test_se_i INVX1 $PINS Y=FE_OFN61_test_se_i A=FE_OFN59_test_se_i
XFE_OFC60_test_se_i INVX2 $PINS Y=FE_OFN60_test_se_i A=FE_OFN59_test_se_i
XFE_OFC59_test_se_i INVX1 $PINS Y=FE_OFN59_test_se_i A=FE_OFN19_test_se_i
XFE_OFC58_test_se_i CLKBUFX2 $PINS Y=FE_OFN58_test_se_i A=FE_OFN57_test_se_i
XFE_OFC57_test_se_i CLKBUFX2 $PINS Y=FE_OFN57_test_se_i A=FE_OFN56_test_se_i
XFE_OFC56_test_se_i CLKBUFX2 $PINS Y=FE_OFN56_test_se_i A=FE_OFN3_test_se_i
XFE_OFC55_test_se_i CLKBUFX2 $PINS Y=FE_OFN55_test_se_i A=FE_OFN54_test_se_i
XFE_OFC22_test_se_i CLKBUFX3 $PINS Y=FE_OFN22_test_se_i A=FE_OFN74_test_se_i
XFE_OFC19_test_se_i CLKBUFX3 $PINS Y=FE_OFN19_test_se_i A=FE_OFN76_test_se_i
XFE_OFC17_test_se_i CLKBUFX3 $PINS Y=FE_OFN17_test_se_i A=FE_OFN76_test_se_i
XFE_OFC12_test_se_i CLKBUFX3 $PINS Y=FE_OFN12_test_se_i A=FE_OFN0_test_se_i
XFE_OFC11_test_se_i CLKBUFX3 $PINS Y=FE_OFN11_test_se_i A=FE_OFN113_test_se_i
XFE_OFC9_test_se_i CLKBUFX3 $PINS Y=FE_OFN9_test_se_i A=FE_OFN112_test_se_i
XFE_OFC3_test_se_i CLKBUFX3 $PINS Y=FE_OFN3_test_se_i A=FE_OFN114_test_se_i
XU5 XNOR2X1 $PINS Y=n4849 B=n4847 A=n4848
XU6 OAI221XL $PINS Y=n4848 C0=n4840 B1=n4404 B0=n4841 A1=n4846 A0=n4406
XU7 XNOR2X1 $PINS Y=n4890 B=n4878 A=n4879
XU8 OAI221XL $PINS Y=n4879 C0=n4871 B1=n4404 B0=n4872 A1=n4877 A0=n4406
XU9 INVX1 $PINS Y=n4677 A=next_RData1[29]
XU11 XNOR2X1 $PINS Y=n4806 B=n4794 A=n4795
XU12 OAI221XL $PINS Y=n4794 C0=n4791 B1=n4413 B0=n4792 A1=n4793 A0=n4416
XU14 INVX1 $PINS Y=n4717 A=next_RData1[25]
XU15 OAI221XL $PINS Y=n4830 C0=n4822 B1=n4404 B0=n4823 A1=n4828 A0=n4406
XU16 INVX1 $PINS Y=n4823 A=next_RData1[15]
XU17 OAI221XL $PINS Y=n4870 C0=n4862 B1=n4404 B0=n4863 A1=n4868 A0=n4406
XU18 OAI221XL $PINS Y=n4795 C0=n4787 B1=n4404 B0=n4788 A1=n4793 A0=n4406
XU19 XNOR2X1 $PINS Y=n4976 B=n4956 A=n4957
XU20 OAI221XL $PINS Y=n4957 C0=n4949 B1=n4404 B0=n4950 A1=n4955 A0=n4406
XU21 INVX1 $PINS Y=n4954 A=next_RData2[0]
XU22 OAI221XL $PINS Y=n4745 C0=n4742 B1=n4414 B0=n4743 A1=n4744 A0=n4415
XU23 OAI221XL $PINS Y=n4776 C0=n4773 B1=n4414 B0=n4774 A1=n4775 A0=n4416
XU24 OAI221XL $PINS Y=n4908 C0=n4905 B1=n4413 B0=n4906 A1=n4907 A0=n4416
XU25 OAI221XL $PINS Y=n4785 C0=n4782 B1=n4413 B0=n4783 A1=n4784 A0=n4416
XU26 OAI221XL $PINS Y=n4917 C0=n4914 B1=n4413 B0=n4915 A1=n4916 A0=n4415
XU27 OAI221XL $PINS Y=n4724 C0=n4716 B1=n4404 B0=n4717 A1=n4722 A0=n4406
XU28 CLKINVX1 $PINS Y=n4936 A=next_RData2[2]
XU29 CLKINVX1 $PINS Y=n4932 A=next_RData1[2]
XU30 CLKINVX1 $PINS Y=n4752 A=next_RData2[20]
XU33 OAI221XL $PINS Y=n4956 C0=n4953 B1=n4413 B0=n4954 A1=n4955 A0=n4416
XU35 CLKINVX1 $PINS Y=n4970 A=next_RData2[1]
XU38 XNOR2X1 $PINS Y=n4850 B=n4838 A=n4839
XU43 OAI221XL $PINS Y=n4697 C0=n4689 B1=n4404 B0=n4690 A1=n4695 A0=n4406
XU44 OAI221XL $PINS Y=n4715 C0=n4707 B1=n4404 B0=n4708 A1=n4713 A0=n4406
XU45 OAI221XL $PINS Y=n4706 C0=n4698 B1=n4404 B0=n4699 A1=n4704 A0=n4406
XU46 XNOR2X1 $PINS Y=n4686 B=n4674 A=n4675
XU48 XNOR2X1 $PINS Y=n4685 B=n4683 A=n4684
XU49 OAI221XL $PINS Y=n4684 C0=n4676 B1=n4404 B0=n4677 A1=n4682 A0=n4406
XU50 NOR2X1 $PINS Y=n4204 B=regfile[1][10] A=n4269
XU51 NAND2X1 $PINS Y=n3856 B=n4250 A=n4251
XU52 MXI2X1 $PINS Y=N138 S0=N21 B=n194 A=n193
XU53 MXI2X1 $PINS Y=N122 S0=n3732 B=n227 A=n226
XU54 CLKMX2X2 $PINS Y=next_RData2[19] S0=FE_OFN124_n4438 B=RData2[19] A=N160
XU55 CLKMX2X2 $PINS Y=next_RData2[30] S0=n4440 B=RData2[30] A=N149
XU56 CLKMX2X2 $PINS Y=next_RData1[30] S0=n4440 B=RData1[30] A=N117
XU57 CLKMX2X2 $PINS Y=next_RData2[10] S0=FE_OFN124_n4438 B=RData2[10] A=N169
XU58 CLKMX2X2 $PINS Y=next_RData2[3] S0=n4439 B=RData2[3] A=N176
XU59 CLKMX2X2 $PINS Y=next_RData2[6] S0=n4439 B=RData2[6] A=N173
XU60 CLKMX2X2 $PINS Y=next_RData2[7] S0=n4439 B=RData2[7] A=N172
XU61 CLKMX2X2 $PINS Y=next_RData2[5] S0=n4439 B=RData2[5] A=N174
XU62 CLKMX2X2 $PINS Y=next_RData2[14] S0=FE_OFN124_n4438 B=RData2[14] A=N165
XU63 CLKMX2X2 $PINS Y=next_RData2[4] S0=n4439 B=RData2[4] A=N175
XU64 MX4XL $PINS Y=n198 S1=n3739 S0=N20 D=n328 C=n330 B=n329 A=n331
XU65 NAND2X1 $PINS Y=n3864 B=n4245 A=n4246
XU66 CLKINVX1 $PINS Y=n4431 A=N18
XU67 NOR4XL $PINS Y=n185 D=Instruction[8] C=Instruction[9] B=n4429 A=N18
XU68 MXI4XL $PINS Y=n309 S1=N18 S0=n3769 D=regfile[11][8] C=regfile[10][8]
+ B=regfile[9][8] A=regfile[8][8]
XU69 MXI4XL $PINS Y=n301 S1=N18 S0=n3769 D=regfile[11][7] C=regfile[10][7]
+ B=regfile[9][7] A=regfile[8][7]
XU70 MXI4XL $PINS Y=n302 S1=N18 S0=n3769 D=regfile[7][7] C=regfile[6][7]
+ B=regfile[5][7] A=regfile[4][7]
XU71 MXI4XL $PINS Y=n300 S1=N18 S0=n3768 D=regfile[15][7] C=regfile[14][7]
+ B=regfile[13][7] A=regfile[12][7]
XU72 MXI4XL $PINS Y=n299 S1=N18 S0=n3768 D=regfile[19][7] C=regfile[18][7]
+ B=regfile[17][7] A=regfile[16][7]
XU73 MXI4XL $PINS Y=n293 S1=N18 S0=n3768 D=regfile[11][6] C=regfile[10][6]
+ B=regfile[9][6] A=regfile[8][6]
XU74 MXI4XL $PINS Y=n289 S1=N18 S0=n3768 D=regfile[27][6] C=regfile[26][6]
+ B=regfile[25][6] A=regfile[24][6]
XU75 MXI4XL $PINS Y=n292 S1=N18 S0=n3768 D=regfile[15][6] C=regfile[14][6]
+ B=regfile[13][6] A=regfile[12][6]
XU76 MXI4XL $PINS Y=n291 S1=N18 S0=n3768 D=regfile[19][6] C=regfile[18][6]
+ B=regfile[17][6] A=regfile[16][6]
XU77 MXI4XL $PINS Y=n294 S1=N18 S0=n3768 D=regfile[7][6] C=regfile[6][6]
+ B=regfile[5][6] A=regfile[4][6]
XU78 CLKBUFX2 $PINS Y=n3741 A=N18
XU79 NAND2X1 $PINS Y=n4643 B=MEM_RegWrite A=n4417
XU80 MX4X1 $PINS Y=n195 S1=n3739 S0=N20 D=n324 C=n326 B=n325 A=n327
XU81 MX4X1 $PINS Y=n193 S1=n3739 S0=N20 D=n316 C=n318 B=n317 A=n319
XU82 MX4X1 $PINS Y=n201 S1=n3739 S0=N20 D=n348 C=n350 B=n349 A=n351
XU83 MX4X1 $PINS Y=n189 S1=n3739 S0=N20 D=n308 C=n310 B=n309 A=n311
XU84 MX4X1 $PINS Y=n226 S1=N19 S0=n3736 D=n444 C=n446 B=n445 A=n447
XU85 MX4X1 $PINS Y=n223 S1=N19 S0=n3736 D=n436 C=n438 B=n437 A=n439
XU86 MX4X1 $PINS Y=n221 S1=n3738 S0=n3736 D=n428 C=n430 B=n429 A=n431
XU87 MX4X1 $PINS Y=n217 S1=N19 S0=n3736 D=n412 C=n414 B=n413 A=n415
XU129 CLKMX2X2 $PINS Y=next_RData2[29] S0=n4440 B=RData2[29] A=N150
XU130 MXI2X1 $PINS Y=N150 S0=n4257 B=n3836 A=n3835
XU131 CLKMX2X2 $PINS Y=next_RData2[24] S0=n4440 B=RData2[24] A=N155
XU132 MXI2X2 $PINS Y=N155 S0=n4257 B=n3826 A=n3825
XU133 CLKMX2X2 $PINS Y=next_RData2[13] S0=FE_OFN124_n4438 B=RData2[13] A=N166
XU134 MXI2X1 $PINS Y=N166 S0=N26 B=n3804 A=n3803
XU135 CLKMX2X2 $PINS Y=next_RData2[25] S0=n4440 B=RData2[25] A=N154
XU136 MXI2X1 $PINS Y=N154 S0=n4257 B=n3828 A=n3827
XU137 MXI2X1 $PINS Y=n3705 S0=n3773 B=n3702 A=n1575
XU138 MXI2X1 $PINS Y=N117 S0=n3732 B=n237 A=n236
XU139 MXI2X1 $PINS Y=N133 S0=N21 B=n204 A=n203
XU140 CLKMX2X2 $PINS Y=next_RData2[11] S0=FE_OFN124_n4438 B=RData2[11] A=N168
XU141 MXI2X1 $PINS Y=N168 S0=N26 B=n3800 A=n3799
XU142 CLKMX2X2 $PINS Y=next_RData2[2] S0=n4439 B=RData2[2] A=N177
XU143 MXI2X2 $PINS Y=N177 S0=N26 B=n3782 A=n3781
XU144 CLKMX2X2 $PINS Y=next_RData2[8] S0=FE_OFN124_n4438 B=RData2[8] A=N171
XU145 MXI2X1 $PINS Y=N171 S0=N26 B=n3794 A=n3793
XU146 XOR2X1 $PINS Y=n100 B=n4860 A=n4861
XU147 OAI221XL $PINS Y=n4860 C0=n4857 B1=n4413 B0=n4858 A1=n4859 A0=n4416
XU148 XNOR2X1 $PINS Y=n4765 B=n4763 A=n4764
XU149 CLKMX2X2 $PINS Y=next_RData2[9] S0=FE_OFN124_n4438 B=RData2[9] A=N170
XU150 MXI2X1 $PINS Y=N170 S0=N26 B=n3796 A=n3795
XU151 MXI2X1 $PINS Y=N116 S0=n3732 B=n239 A=n238
XU152 MX4X1 $PINS Y=n205 S1=N19 S0=n3735 D=n364 C=n366 B=n365 A=n367
XU153 MX4X1 $PINS Y=n3821 S1=n4264 S0=n4261 D=n4021 C=n4023 B=n4022 A=n4024
XU154 MX4X1 $PINS Y=n3811 S1=n4263 S0=N25 D=n3981 C=n3983 B=n3982 A=n3984
XU155 MXI2X2 $PINS Y=N176 S0=N26 B=n3784 A=n3783
XU156 MXI2X1 $PINS Y=N141 S0=N21 B=n174 A=n173
XU157 MXI2X1 $PINS Y=N145 S0=N21 B=n161 A=n160
XU158 MXI2X1 $PINS Y=N121 S0=n3732 B=n229 A=n228
XU159 MXI2X1 $PINS Y=N174 S0=N26 B=n3788 A=n3787
XU160 MXI2X1 $PINS Y=N140 S0=N21 B=n188 A=n175
XU161 MXI2X2 $PINS Y=N128 S0=N21 B=n214 A=n213
XU162 MXI2X1 $PINS Y=N131 S0=N21 B=n208 A=n207
XU163 MXI2X1 $PINS Y=N143 S0=N21 B=n165 A=n164
XU164 MXI2X1 $PINS Y=N156 S0=n4257 B=n3824 A=n3823
XU165 MXI2X1 $PINS Y=N125 S0=n3732 B=n220 A=n219
XU166 MXI2X1 $PINS Y=N147 S0=N21 B=n157 A=n156
XU167 MXI2X1 $PINS Y=N161 S0=N26 B=n3814 A=n3813
XU168 MXI2X1 $PINS Y=N144 S0=N21 B=n163 A=n162
XU169 MXI2X2 $PINS Y=N172 S0=N26 B=n3792 A=n3791
XU170 MX4X1 $PINS Y=n3791 S1=n4262 S0=n4259 D=n3901 C=n3903 B=n3902 A=n3904
XU171 MXI2X1 $PINS Y=N160 S0=N26 B=n3816 A=n3815
XU172 MX4X1 $PINS Y=n3815 S1=n4263 S0=N25 D=n3997 C=n3999 B=n3998 A=n4000
XU173 OAI221XL $PINS Y=n4861 C0=n4853 B1=n4404 B0=n4854 A1=n4859 A0=n4406
XU175 MX4X1 $PINS Y=n3789 S1=n4262 S0=n4259 D=n3893 C=n3895 B=n3894 A=n3896
XU176 MXI2X1 $PINS Y=N119 S0=n3732 B=n233 A=n232
XU177 MX4X1 $PINS Y=n232 S1=n3740 S0=n3737 D=n468 C=n470 B=n469 A=n471
XU178 MXI2X1 $PINS Y=N120 S0=n3732 B=n231 A=n230
XU179 MX4X1 $PINS Y=n230 S1=n3740 S0=n3737 D=n460 C=n462 B=n461 A=n463
XU180 MXI2X1 $PINS Y=N163 S0=N26 B=n3810 A=n3809
XU181 MX4X1 $PINS Y=n3809 S1=n4263 S0=N25 D=n3973 C=n3975 B=n3974 A=n3976
XU182 MXI2X1 $PINS Y=N136 S0=N21 B=n198 A=n197
XU183 MXI2X1 $PINS Y=N135 S0=N21 B=n200 A=n199
XU184 XNOR2X1 $PINS Y=n4688 B=n4656 A=n4657
XU185 OAI221XL $PINS Y=n4656 C0=n4653 B1=n4414 B0=n4654 A1=n4655 A0=n4415
XU186 MXI2X2 $PINS Y=N175 S0=N26 B=n3786 A=n3785
XU187 MX4X1 $PINS Y=n3785 S1=n4262 S0=n4259 D=n3877 C=n3879 B=n3878 A=n3880
XU188 MXI2X1 $PINS Y=N123 S0=n3732 B=n225 A=n223
XU189 MXI2X1 $PINS Y=N179 S0=n4257 B=n3778 A=n3777
XU190 MX4X1 $PINS Y=n3777 S1=n4264 S0=N25 D=n3845 C=n3847 B=n3846 A=n3848
XU191 MXI2X1 $PINS Y=N118 S0=n3732 B=n235 A=n234
XU192 MX4X1 $PINS Y=n234 S1=n3740 S0=n3737 D=n476 C=n478 B=n477 A=n479
XU193 MXI2X1 $PINS Y=N134 S0=N21 B=n202 A=n201
XU194 MXI2X1 $PINS Y=N139 S0=N21 B=n190 A=n189
XU195 XNOR2X1 $PINS Y=n4852 B=n4820 A=n4821
XU196 OAI221XL $PINS Y=n4820 C0=n4817 B1=n4413 B0=n4818 A1=n4819 A0=n4416
XU197 MXI2X1 $PINS Y=N130 S0=N21 B=n210 A=n209
XU198 MX4X1 $PINS Y=n209 S1=N19 S0=n3735 D=n380 C=n382 B=n381 A=n383
XU199 XNOR2X1 $PINS Y=n4687 B=n4665 A=n4666
XU200 OAI221XL $PINS Y=n4665 C0=n4662 B1=n4414 B0=n4663 A1=n4664 A0=n4415
XU201 NOR2BX1 $PINS Y=n4222 B=regfile[3][6] AN=n4277
XU202 OAI221XL $PINS Y=n4657 C0=n4647 B1=n4404 B0=n4648 A1=n4655 A0=n4406
XU203 OAI221XL $PINS Y=n4674 C0=n4671 B1=n4414 B0=n4672 A1=n4673 A0=n4415
XU204 OAI221XL $PINS Y=n4838 C0=n4835 B1=n4969 B0=n4836 A1=n4837 A0=n4416
XU205 XNOR2X1 $PINS Y=n4930 B=n4908 A=n4909
XU206 OAI221XL $PINS Y=n4683 C0=n4680 B1=n4414 B0=n4681 A1=n4682 A0=n4415
XU207 OAI221XL $PINS Y=n4666 C0=n4658 B1=n4961 B0=n4659 A1=n4664 A0=n4963
XU208 XNOR2X1 $PINS Y=n4726 B=n4714 A=n4715
XU209 OAI221XL $PINS Y=n4714 C0=n4711 B1=n4414 B0=n4712 A1=n4713 A0=n4415
XU210 OAI221XL $PINS Y=n4847 C0=n4844 B1=n4969 B0=n4845 A1=n4846 A0=n4416
XU211 XNOR2X1 $PINS Y=n4891 B=n4869 A=n4870
XU212 OAI221XL $PINS Y=n4869 C0=n4866 B1=n4969 B0=n4867 A1=n4868 A0=n4416
XU213 OAI221XL $PINS Y=n4878 C0=n4875 B1=n4414 B0=n4876 A1=n4877 A0=n4416
XU214 XNOR2X1 $PINS Y=n4725 B=n4723 A=n4724
XU215 OAI221XL $PINS Y=n4723 C0=n4720 B1=n4414 B0=n4721 A1=n4722 A0=n4415
XU216 XNOR2X1 $PINS Y=n4889 B=n4887 A=n4888
XU217 OAI221XL $PINS Y=n4887 C0=n4884 B1=n4413 B0=n4885 A1=n4886 A0=n4416
XU218 XNOR2X1 $PINS Y=n4807 B=n4785 A=n4786
XU219 XNOR2X1 $PINS Y=n4929 B=n4917 A=n4918
XU220 XNOR2X1 $PINS Y=n4805 B=n4803 A=n4804
XU221 OAI221XL $PINS Y=n4803 C0=n4800 B1=n4414 B0=n4801 A1=n4802 A0=n4416
XU222 OAI221XL $PINS Y=n4973 C0=n4968 B1=n4413 B0=n4970 A1=n4971 A0=n4416
XU223 MXI2X1 $PINS Y=N146 S0=N21 B=n159 A=n158
XU224 MX4X1 $PINS Y=n158 S1=n3740 S0=n3733 D=n252 C=n254 B=n253 A=n255
XU225 OAI221XL $PINS Y=n4754 C0=n4751 B1=n4414 B0=n4752 A1=n4753 A0=n4415
XU226 XNOR2X1 $PINS Y=n4928 B=n4926 A=n4927
XU227 OAI221XL $PINS Y=n4926 C0=n4923 B1=n4413 B0=n4924 A1=n4925 A0=n4416
XU228 OAI221XL $PINS Y=n4763 C0=n4760 B1=n4414 B0=n4761 A1=n4762 A0=n4415
XU229 INVX1 $PINS Y=n4761 A=next_RData2[21]
XU230 MXI2X1 $PINS Y=n4250 S0=n4297 B=n4247 A=n1579
XU231 OAI221XL $PINS Y=n4888 C0=n4880 B1=n4404 B0=n4881 A1=n4886 A0=n4406
XU232 XNOR2X1 $PINS Y=n4808 B=n4776 A=n4777
XU233 OAI221XL $PINS Y=n4777 C0=n4769 B1=n4404 B0=n4770 A1=n4775 A0=n4406
XU234 NOR2X1 $PINS Y=n4206 B=n4203 A=n4204
XU235 XNOR2X1 $PINS Y=n4767 B=n4745 A=n4746
XU237 OAI221XL $PINS Y=n4927 C0=n4919 B1=n4961 B0=n4920 A1=n4925 A0=n4406
XU238 NAND2X1 $PINS Y=n255 B=n3725 A=n3726
XU239 MXI2X1 $PINS Y=n3725 S0=n3772 B=n3722 A=n1579
XU240 XNOR2X1 $PINS Y=n4766 B=n4754 A=n4755
XU243 XNOR2X1 $PINS Y=n4728 B=n4696 A=n4697
XU244 OAI221XL $PINS Y=n4696 C0=n4693 B1=n4414 B0=n4694 A1=n4695 A0=n4415
XU245 XNOR2X1 $PINS Y=n4851 B=n4829 A=n4830
XU246 OAI221XL $PINS Y=n4829 C0=n4826 B1=n4413 B0=n4827 A1=n4828 A0=n4416
XU247 XNOR2X1 $PINS Y=n4727 B=n4705 A=n4706
XU248 OAI221XL $PINS Y=n4705 C0=n4702 B1=n4414 B0=n4703 A1=n4704 A0=n4415
XU250 OAI221XL $PINS Y=n4899 C0=n4896 B1=n4413 B0=n4897 A1=n4898 A0=n4415
XU251 XNOR2X1 $PINS Y=n4768 B=n4736 A=n4737
XU252 OAI221XL $PINS Y=n4736 C0=n4733 B1=n4414 B0=n4734 A1=n4735 A0=n4415
XU253 OAI221XL $PINS Y=n4938 C0=n4935 B1=n4413 B0=n4936 A1=n4937 A0=n4415
XU254 MXI2X1 $PINS Y=N126 S0=n3732 B=n218 A=n217
XU255 MXI2X1 $PINS Y=N127 S0=n3732 B=n216 A=n215
XU256 MX4X1 $PINS Y=n215 S1=n3739 S0=n3736 D=n404 C=n406 B=n405 A=n407
XU257 MXI2X1 $PINS Y=N124 S0=n3732 B=n222 A=n221
XU258 MXI2X1 $PINS Y=N137 S0=N21 B=n196 A=n195
XU259 MXI2X1 $PINS Y=N129 S0=N21 B=n212 A=n211
XU260 MX4X1 $PINS Y=n211 S1=N19 S0=n3735 D=n388 C=n390 B=n389 A=n391
XU261 AND2XL $PINS Y=n4237 B=n1545 A=n4269
XU262 XNOR2X1 $PINS Y=n4977 B=n4947 A=n4948
XU263 OAI221XL $PINS Y=n4947 C0=n4944 B1=n4413 B0=n4945 A1=n4946 A0=n4972
XU264 NOR2X1 $PINS Y=equal B=n103 A=n102
XU265 OR4X1 $PINS Y=n103 D=n4978 C=n4979 B=n4980 A=n4981
XU266 OR4X1 $PINS Y=n102 D=n4809 C=n4810 B=n4811 A=n4812
XU267 OAI221XL $PINS Y=n4939 C0=n4931 B1=n4404 B0=n4932 A1=n4937 A0=n4406
XU269 OR2X1 $PINS Y=n96 B=n4961 A=n4893
XU270 OR2XL $PINS Y=n95 B=n4898 A=n4406
XU272 NOR2X1 $PINS Y=n4224 B=n4275 A=regfile[1][6]
XU273 NOR2X1 $PINS Y=n4244 B=n4275 A=regfile[1][2]
XU274 XOR2X1 $PINS Y=n99 B=n4939 A=n4938
XU275 CLKINVX1 $PINS Y=n4655 A=EX_RegWriteData[30]
XU276 INVXL $PINS Y=n4425 A=N24
XU277 INVXL $PINS Y=n4434 A=N20
XU278 INVXL $PINS Y=n4432 A=N19
XU281 NOR2X1 $PINS Y=n4219 B=regfile[1][7] A=n4275
XU285 NOR2X1 $PINS Y=n4174 B=regfile[1][16] A=n4278
XU286 NOR2X1 $PINS Y=n4169 B=regfile[1][17] A=n4276
XU287 NOR2X1 $PINS Y=n4164 B=regfile[1][18] A=n4280
XU289 NOR2X1 $PINS Y=n4154 B=regfile[1][20] A=n4277
XU290 NOR2X1 $PINS Y=n4139 B=regfile[1][23] A=n4269
XU291 NOR2X1 $PINS Y=n4149 B=regfile[1][21] A=n4268
XU292 NOR2X1 $PINS Y=n4144 B=regfile[1][22] A=n4270
XU294 NOR2X1 $PINS Y=n4119 B=regfile[1][27] A=n4277
XU295 NOR2X1 $PINS Y=n4129 B=n4274 A=regfile[1][25]
XU296 NOR2X1 $PINS Y=n4124 B=regfile[1][26] A=n4270
XU297 NOR2X1 $PINS Y=n4179 B=regfile[1][15] A=n4268
XU298 NOR2X1 $PINS Y=n4099 B=regfile[1][31] A=n4277
XU299 NOR2X1 $PINS Y=n4114 B=regfile[1][28] A=n4275
XU300 NOR2X1 $PINS Y=n4109 B=n4279 A=regfile[1][29]
XU301 NOR2X1 $PINS Y=n4104 B=regfile[1][30] A=n4270
XU302 NOR2X1 $PINS Y=n4214 B=n4270 A=regfile[1][8]
XU304 NOR2X1 $PINS Y=n4194 B=regfile[1][12] A=n4280
XU305 NOR2X1 $PINS Y=n4189 B=regfile[1][13] A=n4274
XU306 NOR2X1 $PINS Y=n4184 B=regfile[1][14] A=n4276
XU307 NOR2X1 $PINS Y=n4249 B=n4274 A=regfile[1][1]
XU308 NOR2BX1 $PINS Y=n4157 B=n94 AN=n4276
XU309 NOR2BX1 $PINS Y=n4172 B=regfile[3][16] AN=n4279
XU310 NOR2BX1 $PINS Y=n4167 B=regfile[3][17] AN=n4269
XU311 NOR2BX1 $PINS Y=n4162 B=n91 AN=n4274
XU312 NOR2BX1 $PINS Y=n4152 B=n85 AN=n4268
XU313 NOR2BX1 $PINS Y=n4137 B=n87 AN=n4268
XU314 NOR2BX1 $PINS Y=n4147 B=regfile[3][21] AN=n4268
XU315 NOR2BX1 $PINS Y=n4217 B=n89 AN=n4278
XU316 NOR2BX1 $PINS Y=n4142 B=regfile[3][22] AN=n4268
XU317 NOR2BX1 $PINS Y=n4207 B=regfile[3][9] AN=n4268
XU318 NOR2BX1 $PINS Y=n4212 B=regfile[3][8] AN=n4274
XU319 NOR2BX1 $PINS Y=n4197 B=regfile[3][11] AN=n4277
XU320 NOR2BX1 $PINS Y=n4132 B=regfile[3][24] AN=n4276
XU321 NOR2BX1 $PINS Y=n4177 B=regfile[3][15] AN=n4270
XU322 NOR2BX1 $PINS Y=n4187 B=regfile[3][13] AN=n4275
XU323 NOR2BX1 $PINS Y=n4182 B=regfile[3][14] AN=n4277
XU324 NOR2BX1 $PINS Y=n4227 B=regfile[3][5] AN=n4269
XU325 NOR2BX1 $PINS Y=n4252 B=n92 AN=n4280
XU326 NOR2BX1 $PINS Y=n4242 B=regfile[3][2] AN=n4278
XU327 NOR2BX1 $PINS Y=n4232 B=n90 AN=n4269
XU328 NOR2BX1 $PINS Y=n4117 B=regfile[3][27] AN=n4269
XU329 NOR2BX1 $PINS Y=n4127 B=regfile[3][25] AN=n4275
XU330 NOR2BX1 $PINS Y=n4122 B=regfile[3][26] AN=n4279
XU331 NOR2BX1 $PINS Y=n4192 B=regfile[3][12] AN=n4274
XU332 NOR2BX1 $PINS Y=n4097 B=regfile[3][31] AN=n4280
XU333 NOR2BX1 $PINS Y=n4112 B=regfile[3][28] AN=n4268
XU334 NOR2BX1 $PINS Y=n4107 B=regfile[3][29] AN=n4269
XU335 NOR2BX1 $PINS Y=n4102 B=regfile[3][30] AN=n4270
XU336 NOR2BX1 $PINS Y=n4247 B=regfile[3][1] AN=n4270
XU337 NAND4X1 $PINS Y=n4811 D=n4725 C=n4726 B=n4727 A=n4728
XU338 NAND2X1 $PINS Y=n4982 B=equal A=Branch
XU339 NAND4X1 $PINS Y=n4810 D=n4765 C=n4766 B=n4767 A=n4768
XU340 NAND4X1 $PINS Y=n4809 D=n4805 C=n4806 B=n4807 A=n4808
XU341 NAND4X1 $PINS Y=n4812 D=n4688 C=n4686 B=n4687 A=n4685
XU342 NAND4X1 $PINS Y=n4981 D=n4849 C=n4850 B=n4851 A=n4852
XU344 NAND4BX1 $PINS Y=n4978 D=n4975 C=n4976 B=n4977 AN=n99
XU345 NAND4BX1 $PINS Y=n4980 D=n4889 C=n4890 B=n4891 AN=n100
XU346 CLKINVX1 $PINS Y=n4422 A=n4423
XU347 CLKINVX1 $PINS Y=n4448 A=stall
XU348 CLKINVX3 $PINS Y=n4423 A=N22
XU349 CLKINVX1 $PINS Y=n4427 A=N25
XU350 INVX2 $PINS Y=n4430 A=N17
XU351 INVX3 $PINS Y=n4424 A=N23
XU352 CLKINVX1 $PINS Y=n4428 A=N26
XU353 CLKINVX1 $PINS Y=n4435 A=N21
XU354 CLKMX2X2 $PINS Y=next_RData2[28] S0=n4439 B=RData2[28] A=N151
XU355 CLKMX2X2 $PINS Y=next_RData1[31] S0=n4440 B=RData1[31] A=N116
XU356 CLKMX2X2 $PINS Y=next_RData1[26] S0=n4440 B=RData1[26] A=N121
XU357 CLKMX2X2 $PINS Y=next_RData1[27] S0=n4440 B=RData1[27] A=N120
XU358 CLKMX2X2 $PINS Y=next_RData1[28] S0=n4439 B=RData1[28] A=N119
XU359 CLKMX2X2 $PINS Y=next_RData1[25] S0=n4440 B=RData1[25] A=N122
XU360 CLKMX2X2 $PINS Y=next_RData1[29] S0=n4439 B=RData1[29] A=N118
XU361 CLKMX2X2 $PINS Y=next_RData1[19] S0=n4437 B=RData1[19] A=N128
XU362 CLKMX2X2 $PINS Y=next_RData1[22] S0=n4440 B=RData1[22] A=N125
XU363 CLKMX2X2 $PINS Y=next_RData1[2] S0=n4439 B=RData1[2] A=N145
XU364 CLKMX2X2 $PINS Y=next_RData1[0] S0=n4439 B=RData1[0] A=N147
XU365 CLKMX2X2 $PINS Y=next_RData1[20] S0=n4440 B=RData1[20] A=N127
XU366 CLKMX2X2 $PINS Y=next_RData1[3] S0=n4439 B=RData1[3] A=N144
XU367 CLKMX2X2 $PINS Y=next_RData1[24] S0=n4440 B=RData1[24] A=N123
XU368 CLKMX2X2 $PINS Y=next_RData1[4] S0=n4439 B=RData1[4] A=N143
XU369 CLKMX2X2 $PINS Y=next_RData1[6] S0=n4439 B=RData1[6] A=N141
XU370 CLKMX2X2 $PINS Y=next_RData1[7] S0=n4439 B=RData1[7] A=N140
XU371 CLKMX2X2 $PINS Y=next_RData1[21] S0=n4440 B=RData1[21] A=N126
XU372 CLKMX2X2 $PINS Y=next_RData1[1] S0=n4439 B=RData1[1] A=N146
XU373 CLKMX2X2 $PINS Y=next_RData1[5] S0=n4439 B=RData1[5] A=N142
XU374 CLKMX2X2 $PINS Y=next_RData1[15] S0=FE_OFN124_n4438 B=RData1[15] A=N132
XU375 CLKMX2X2 $PINS Y=next_RData1[14] S0=FE_OFN124_n4438 B=RData1[14] A=N133
XU376 CLKMX2X2 $PINS Y=next_RData1[11] S0=FE_OFN124_n4438 B=RData1[11] A=N136
XU377 CLKMX2X2 $PINS Y=next_RData1[10] S0=FE_OFN124_n4438 B=RData1[10] A=N137
XU378 CLKMX2X2 $PINS Y=next_RData1[12] S0=FE_OFN124_n4438 B=RData1[12] A=N135
XU379 CLKMX2X2 $PINS Y=next_RData1[8] S0=FE_OFN124_n4438 B=RData1[8] A=N139
XU380 CLKMX2X2 $PINS Y=next_RData1[9] S0=FE_OFN124_n4438 B=RData1[9] A=N138
XU381 CLKMX2X2 $PINS Y=next_RData1[13] S0=FE_OFN124_n4438 B=RData1[13] A=N134
XU382 CLKMX2X2 $PINS Y=next_RData1[23] S0=n4441 B=RData1[23] A=N124
XU383 CLKMX2X2 $PINS Y=next_RData1[18] S0=n4441 B=RData1[18] A=N129
XU384 CLKMX2X2 $PINS Y=next_RData1[16] S0=n4441 B=RData1[16] A=N131
XU385 CLKMX2X2 $PINS Y=next_RData1[17] S0=n4441 B=RData1[17] A=N130
XU386 INVXL $PINS Y=n4989 A=BranchTaken
XU387 CLKMX2X2 $PINS Y=next_RData2[31] S0=n4440 B=RData2[31] A=N148
XU388 CLKMX2X2 $PINS Y=next_RData2[22] S0=n4440 B=RData2[22] A=N157
XU389 CLKMX2X2 $PINS Y=next_RData2[0] S0=n4439 B=RData2[0] A=N179
XU390 CLKMX2X2 $PINS Y=next_RData2[20] S0=n4440 B=RData2[20] A=N159
XU391 CLKMX2X2 $PINS Y=next_RData2[26] S0=n4440 B=RData2[26] A=N153
XU392 CLKMX2X2 $PINS Y=next_RData2[27] S0=n4440 B=RData2[27] A=N152
XU393 CLKMX2X2 $PINS Y=next_RData2[21] S0=n4440 B=RData2[21] A=N158
XU394 CLKMX2X2 $PINS Y=next_RData2[1] S0=n4439 B=RData2[1] A=N178
XU395 CLKMX2X2 $PINS Y=next_RData2[15] S0=FE_OFN124_n4438 B=RData2[15] A=N164
XU396 CLKMX2X2 $PINS Y=next_RData2[12] S0=FE_OFN124_n4438 B=RData2[12] A=N167
XU397 CLKMX2X2 $PINS Y=next_RData2[23] S0=n4441 B=RData2[23] A=N156
XU398 CLKMX2X2 $PINS Y=next_RData2[18] S0=n4441 B=RData2[18] A=N161
XU399 CLKMX2X2 $PINS Y=next_RData2[16] S0=n4441 B=RData2[16] A=N163
XU400 CLKMX2X2 $PINS Y=next_RData2[17] S0=n4441 B=RData2[17] A=N162
XU401 INVXL $PINS Y=n4580 A=PCadd4[2]
XU402 INVXL $PINS Y=n4582 A=PCadd4[3]
XU403 INVXL $PINS Y=n4584 A=PCadd4[4]
XU404 NAND3XL $PINS Y=n191 C=n224 B=Instruction[27] A=Jump
XU405 AND3XL $PINS Y=n224 C=n170 B=n4983 A=Instruction[26]
XU406 NOR2BXL $PINS Y=n93 B=n4984 AN=Reg_W[3]
XU407 INVX1 $PINS Y=n4983 A=MEM_RegWrite
XU408 INVXL $PINS Y=n4984 A=Reg_W[2]
XU409 NOR2XL $PINS Y=n62 B=Reg_W[3] A=Reg_W[2]
XU410 NOR2BXL $PINS Y=n83 B=Reg_W[2] AN=Reg_W[3]
XU411 NOR2XL $PINS Y=n73 B=Reg_W[3] A=n4984
XU412 NAND2XL $PINS Y=n124 B=Reg_W[0] A=Reg_W[1]
XU413 MX2XL $PINS Y=n1678 S0=n4305 B=WriteData[0] A=n4542
XU414 MX2XL $PINS Y=n1680 S0=n4305 B=WriteData[1] A=n4543
XU415 MX2XL $PINS Y=n1682 S0=n4305 B=WriteData[2] A=n4544
XU416 MX2XL $PINS Y=n1684 S0=n4305 B=WriteData[3] A=SPCASCAN_N37
XU417 MX2XL $PINS Y=n1686 S0=n4305 B=WriteData[4] A=n4546
XU418 MX2XL $PINS Y=n1688 S0=n4305 B=WriteData[5] A=n4547
XU419 MX2XL $PINS Y=n1690 S0=n4305 B=WriteData[6] A=n4548
XU420 MX2XL $PINS Y=n1692 S0=n4305 B=WriteData[7] A=n4549
XU421 MX2XL $PINS Y=n1694 S0=n4305 B=WriteData[8] A=n4550
XU422 MX2XL $PINS Y=n1696 S0=n4305 B=WriteData[9] A=n4551
XU423 MX2XL $PINS Y=n1698 S0=n4305 B=WriteData[10] A=n4552
XU424 MX2XL $PINS Y=n1700 S0=n4305 B=WriteData[11] A=n4553
XU425 MX2XL $PINS Y=n1702 S0=n4305 B=WriteData[12] A=n4554
XU426 MX2XL $PINS Y=n1704 S0=n114 B=WriteData[13] A=n4555
XU427 MX2XL $PINS Y=n1706 S0=n114 B=WriteData[14] A=SPCASCAN_N31
XU428 MX2XL $PINS Y=n1708 S0=n114 B=WriteData[15] A=n4557
XU429 MX2XL $PINS Y=n1710 S0=n114 B=WriteData[16] A=n4558
XU430 MX2XL $PINS Y=n1712 S0=n114 B=WriteData[17] A=n4559
XU431 MX2XL $PINS Y=n1714 S0=n114 B=WriteData[18] A=n4560
XU432 MX2XL $PINS Y=n1716 S0=n114 B=WriteData[19] A=n4561
XU433 MX2XL $PINS Y=n1718 S0=n114 B=WriteData[20] A=n4562
XU434 MX2XL $PINS Y=n1720 S0=n114 B=WriteData[21] A=n4563
XU435 MX2XL $PINS Y=n1722 S0=n114 B=WriteData[22] A=n4564
XU436 MX2XL $PINS Y=n1724 S0=n114 B=WriteData[23] A=n4565
XU437 MX2XL $PINS Y=n1726 S0=n114 B=WriteData[24] A=n4566
XU438 MX2XL $PINS Y=n1728 S0=n114 B=WriteData[25] A=SPCBSCAN_N41
XU439 MX2XL $PINS Y=n1730 S0=n114 B=WriteData[26] A=n4568
XU440 MX2XL $PINS Y=n1732 S0=n4305 B=WriteData[27] A=n4569
XU441 MX2XL $PINS Y=n1738 S0=n114 B=WriteData[30] A=SPCASCAN_N35
XU442 MX2XL $PINS Y=n1740 S0=n114 B=WriteData[31] A=n4573
XU443 CLKBUFX3 $PINS Y=n4302 A=n10
XU444 AO21XL $PINS Y=n10 B0=n12 A1=Instruction[29] A0=Instruction[28]
XU445 OAI21XL $PINS Y=next_Immediate_SE[20] B0=n4302 A1=FE_OFN125_n4445 A0=n613
XU446 OAI21XL $PINS Y=next_Immediate_SE[21] B0=n4302 A1=FE_OFN125_n4445 A0=n614
XU447 OAI21XL $PINS Y=next_Immediate_SE[22] B0=n4302 A1=FE_OFN125_n4445 A0=n615
XU448 OAI21XL $PINS Y=next_Immediate_SE[23] B0=n4302 A1=FE_OFN125_n4445 A0=n616
XU449 OAI21XL $PINS Y=next_Immediate_SE[16] B0=n4302 A1=FE_OFN125_n4445 A0=n608
XU450 OAI21XL $PINS Y=next_Immediate_SE[17] B0=n4302 A1=FE_OFN125_n4445 A0=n609
XU451 OAI21XL $PINS Y=next_Immediate_SE[18] B0=n4302 A1=FE_OFN125_n4445 A0=n610
XU452 OAI21XL $PINS Y=next_Immediate_SE[19] B0=n4302 A1=FE_OFN125_n4445 A0=n611
XU453 MX2XL $PINS Y=n147 S0=n4437 B=Immediate_SE[8] A=Instruction[8]
XU454 OAI21XL $PINS Y=next_Immediate_SE[24] B0=n4302 A1=FE_OFN125_n4445 A0=n617
XU455 OAI21XL $PINS Y=next_Immediate_SE[25] B0=n4302 A1=FE_OFN125_n4445 A0=n618
XU456 OAI21XL $PINS Y=next_Immediate_SE[15] B0=n12 A1=FE_OFN125_n4445 A0=n607
XU457 MX2XL $PINS Y=n149 S0=n4437 B=Immediate_SE[6] A=Instruction[6]
XU458 MX2XL $PINS Y=n150 S0=n4437 B=Immediate_SE[7] A=Instruction[7]
XU459 MX2XL $PINS Y=n151 S0=n4437 B=Immediate_SE[9] A=Instruction[9]
XU460 MX2XL $PINS Y=n143 S0=n4438 B=n1913 A=Instruction[2]
XU461 OAI21XL $PINS Y=next_Immediate_SE[26] B0=n4302 A1=FE_OFN125_n4445 A0=n619
XU462 OAI21XL $PINS Y=next_Immediate_SE[27] B0=n4302 A1=FE_OFN125_n4445 A0=n620
XU463 OAI21XL $PINS Y=next_Immediate_SE[28] B0=n4302 A1=FE_OFN125_n4445 A0=n621
XU464 OAI21XL $PINS Y=next_Immediate_SE[29] B0=n4302 A1=FE_OFN125_n4445 A0=n622
XU465 AND3XL $PINS Y=n169 C=Instruction[26] B=n170 A=Instruction[27]
XU466 NAND4XL $PINS Y=n167 D=MEM_RegWrite C=n170 B=Instruction[26]
+ A=Instruction[27]
XU467 NOR4XL $PINS Y=n183 D=Instruction[27] C=Instruction[2] B=Instruction[3]
+ A=Instruction[4]
XU468 CLKBUFX3 $PINS Y=n4300 A=n4282
XU469 CLKBUFX3 $PINS Y=n3775 A=n4429
XU470 CLKBUFX3 $PINS Y=n4274 A=N23
XU471 CLKBUFX3 $PINS Y=n3749 A=N18
XU473 CLKBUFX3 $PINS Y=n4299 A=n4282
XU474 CLKBUFX3 $PINS Y=n3773 A=n3775
XU475 CLKBUFX3 $PINS Y=n3774 A=n3775
XU476 CLKBUFX3 $PINS Y=n4297 A=n4282
XU477 CLKBUFX3 $PINS Y=n3772 A=n4429
XU478 CLKBUFX3 $PINS Y=n4291 A=n4282
XU479 CLKBUFX3 $PINS Y=n4292 A=n4282
XU480 CLKBUFX3 $PINS Y=n4293 A=n4282
XU481 CLKBUFX3 $PINS Y=n4295 A=n4282
XU482 CLKBUFX3 $PINS Y=n4296 A=n4282
XU483 CLKBUFX3 $PINS Y=n4294 A=n4282
XU484 CLKBUFX3 $PINS Y=n4283 A=n4282
XU485 CLKBUFX3 $PINS Y=n4284 A=n4422
XU486 CLKBUFX3 $PINS Y=n4285 A=n4282
XU487 CLKBUFX3 $PINS Y=n4287 A=n4282
XU488 CLKBUFX3 $PINS Y=n4288 A=n4282
XU489 CLKBUFX3 $PINS Y=n4289 A=n4282
XU490 CLKBUFX3 $PINS Y=n4290 A=n4282
XU491 CLKBUFX3 $PINS Y=n4286 A=n4282
XU492 CLKBUFX3 $PINS Y=n3766 A=n4429
XU493 CLKBUFX3 $PINS Y=n3767 A=n3775
XU494 CLKBUFX3 $PINS Y=n3768 A=n4429
XU495 CLKBUFX3 $PINS Y=n3770 A=n4429
XU496 CLKBUFX3 $PINS Y=n3771 A=n4429
XU497 CLKBUFX3 $PINS Y=n3769 A=n4429
XU498 CLKBUFX3 $PINS Y=n3758 A=n3775
XU499 CLKBUFX3 $PINS Y=n3759 A=n4429
XU500 CLKBUFX3 $PINS Y=n3760 A=n3775
XU501 CLKBUFX3 $PINS Y=n3762 A=n3775
XU502 CLKBUFX3 $PINS Y=n3763 A=n3775
XU503 CLKBUFX3 $PINS Y=n3764 A=n4429
XU504 CLKBUFX3 $PINS Y=n3765 A=n4429
XU505 CLKBUFX3 $PINS Y=n3761 A=n3775
XU506 CLKBUFX3 $PINS Y=n4271 A=FE_OFN214_n4273
XU507 CLKBUFX3 $PINS Y=n4273 A=n4266
XU508 CLKBUFX3 $PINS Y=n4272 A=FE_OFN216_n4267
XU509 CLKBUFX3 $PINS Y=n4266 A=N23
XU510 CLKBUFX3 $PINS Y=n4267 A=N23
XU511 CLKBUFX4 $PINS Y=n4269 A=N23
XU512 CLKBUFX3 $PINS Y=n4270 A=N23
XU513 CLKBUFX3 $PINS Y=n4268 A=N23
XU514 CLKBUFX3 $PINS Y=n3746 A=n3741
XU515 CLKBUFX3 $PINS Y=n3747 A=n3750
XU516 CLKBUFX3 $PINS Y=n3748 A=n3741
XU517 CLKBUFX3 $PINS Y=n3742 A=n3741
XU519 CLKBUFX3 $PINS Y=n3744 A=n3750
XU520 CLKBUFX3 $PINS Y=n3745 A=n3750
XU521 CLKBUFX4 $PINS Y=n4275 A=N23
XU522 CLKBUFX3 $PINS Y=n3750 A=N18
XU525 CLKBUFX3 $PINS Y=n4276 A=N23
XU526 CLKBUFX3 $PINS Y=n4277 A=N23
XU527 CLKBUFX3 $PINS Y=n4278 A=N23
XU528 CLKBUFX3 $PINS Y=n4279 A=N23
XU529 BUFX4 $PINS Y=n3751 A=n3741
XU530 CLKBUFX3 $PINS Y=n3752 A=n3741
XU531 CLKBUFX4 $PINS Y=n3753 A=n3741
XU532 CLKBUFX3 $PINS Y=n3754 A=n3741
XU533 CLKBUFX3 $PINS Y=n4259 A=n4258
XU535 CLKBUFX3 $PINS Y=n4261 A=n4258
XU536 CLKBUFX3 $PINS Y=n3734 A=n3733
XU537 CLKBUFX3 $PINS Y=n3735 A=n3733
XU538 CLKBUFX3 $PINS Y=n3736 A=n3733
XU539 CLKBUFX3 $PINS Y=n3737 A=n4433
XU540 CLKBUFX3 $PINS Y=n4280 A=N23
XU541 CLKBUFX4 $PINS Y=n3755 A=n3741
XU542 CLKBUFX3 $PINS Y=n4262 A=N24
XU543 CLKBUFX3 $PINS Y=n4263 A=N24
XU544 CLKBUFX3 $PINS Y=n4264 A=N24
XU545 CLKBUFX3 $PINS Y=n4265 A=N24
XU546 CLKBUFX3 $PINS Y=n3738 A=N19
XU547 CLKBUFX3 $PINS Y=n3739 A=N19
XU548 CLKBUFX3 $PINS Y=n3740 A=N19
XU549 CLKBUFX3 $PINS Y=n4414 A=n4969
XU550 CLKBUFX3 $PINS Y=n4404 A=n4961
XU552 CLKBUFX3 $PINS Y=n4282 A=n4422
XU553 CLKBUFX3 $PINS Y=n4462 A=n4449
XU554 CLKBUFX3 $PINS Y=n4513 A=n4452
XU555 CLKBUFX3 $PINS Y=n4512 A=n4452
XU556 CLKBUFX3 $PINS Y=n4511 A=n4452
XU558 CLKBUFX3 $PINS Y=n4509 A=n4452
XU561 CLKBUFX3 $PINS Y=n4506 A=n4452
XU562 CLKBUFX3 $PINS Y=n4505 A=FE_OFN159_n4453
XU563 CLKBUFX3 $PINS Y=n4504 A=FE_OFN159_n4453
XU564 CLKBUFX3 $PINS Y=n4503 A=FE_OFN159_n4453
XU565 CLKBUFX3 $PINS Y=n4502 A=FE_OFN159_n4453
XU566 CLKBUFX3 $PINS Y=n4501 A=FE_OFN159_n4453
XU567 CLKBUFX3 $PINS Y=n4500 A=FE_OFN159_n4453
XU568 CLKBUFX3 $PINS Y=n4499 A=FE_OFN159_n4453
XU569 CLKBUFX3 $PINS Y=n4498 A=FE_OFN159_n4453
XU570 CLKBUFX3 $PINS Y=n4497 A=FE_OFN159_n4453
XU571 CLKBUFX3 $PINS Y=n4496 A=FE_OFN159_n4453
XU572 CLKBUFX3 $PINS Y=n4495 A=FE_OFN159_n4453
XU573 CLKBUFX3 $PINS Y=n4494 A=FE_OFN159_n4453
XU574 CLKBUFX3 $PINS Y=n4493 A=FE_OFN159_n4453
XU575 CLKBUFX3 $PINS Y=n4492 A=FE_OFN159_n4453
XU576 CLKBUFX3 $PINS Y=n4491 A=FE_OFN159_n4453
XU577 CLKBUFX3 $PINS Y=n4490 A=FE_OFN159_n4453
XU578 CLKBUFX3 $PINS Y=n4489 A=n4449
XU579 CLKBUFX3 $PINS Y=n4488 A=n4449
XU582 CLKBUFX3 $PINS Y=n4485 A=FE_OFN159_n4453
XU583 CLKBUFX3 $PINS Y=n4484 A=FE_OFN159_n4453
XU584 CLKBUFX3 $PINS Y=n4483 A=FE_OFN159_n4453
XU585 CLKBUFX3 $PINS Y=n4482 A=FE_OFN159_n4453
XU586 CLKBUFX3 $PINS Y=n4481 A=n4449
XU587 CLKBUFX3 $PINS Y=n4480 A=n4449
XU590 CLKBUFX3 $PINS Y=n4477 A=n4449
XU591 CLKBUFX3 $PINS Y=n4476 A=n4449
XU592 CLKBUFX3 $PINS Y=n4475 A=n4449
XU594 CLKBUFX3 $PINS Y=n4473 A=n4449
XU595 CLKBUFX3 $PINS Y=n4472 A=n4449
XU598 CLKBUFX3 $PINS Y=n4469 A=n4453
XU599 CLKBUFX3 $PINS Y=n4468 A=n4453
XU600 CLKBUFX3 $PINS Y=n4467 A=n4453
XU601 CLKBUFX3 $PINS Y=n4466 A=n4453
XU602 CLKBUFX3 $PINS Y=n4465 A=n4449
XU605 CLKBUFX3 $PINS Y=n4461 A=n4453
XU606 CLKBUFX3 $PINS Y=n4460 A=n4453
XU607 CLKBUFX3 $PINS Y=n4459 A=n4453
XU608 CLKBUFX3 $PINS Y=n4458 A=n4453
XU609 CLKBUFX3 $PINS Y=n4457 A=n4449
XU613 CLKBUFX3 $PINS Y=n4453 A=n4449
XU614 CLKBUFX3 $PINS Y=n4452 A=n4449
XU617 INVX3 $PINS Y=n4437 A=n4443
XU618 INVX2 $PINS Y=n4438 A=n4443
XU619 CLKINVX3 $PINS Y=n4439 A=n4443
XU620 CLKBUFX3 $PINS Y=n4406 A=n4963
XU622 CLKBUFX3 $PINS Y=n4415 A=n4972
XU623 CLKBUFX3 $PINS Y=n4416 A=n4972
XU624 CLKBUFX3 $PINS Y=n4411 A=n4967
XU625 CLKBUFX3 $PINS Y=n4402 A=n4959
XU626 CLKBUFX3 $PINS Y=n4408 A=n4965
XU627 CLKBUFX3 $PINS Y=n4400 A=n4958
XU630 CLKBUFX3 $PINS Y=n4413 A=n4969
XU634 CLKBUFX3 $PINS Y=n4258 A=n4426
XU635 CLKBUFX3 $PINS Y=n3733 A=n4433
XU636 CLKBUFX3 $PINS Y=n4257 A=N26
XU637 CLKBUFX3 $PINS Y=n3732 A=N21
XU639 CLKBUFX3 $PINS Y=n4517 A=n4449
XU660 CLKBUFX3 $PINS Y=n4367 A=n4644
XU662 CLKBUFX3 $PINS Y=n4307 A=n105
XU664 CLKBUFX3 $PINS Y=n4315 A=n106
XU665 CLKBUFX3 $PINS Y=n4316 A=n106
XU666 CLKBUFX3 $PINS Y=n4323 A=n108
XU667 CLKBUFX3 $PINS Y=n4324 A=n108
XU668 CLKBUFX3 $PINS Y=n4331 A=n109
XU670 CLKBUFX3 $PINS Y=n4339 A=n110
XU672 CLKBUFX3 $PINS Y=n4347 A=n111
XU674 CLKBUFX3 $PINS Y=n4355 A=n112
XU676 NAND2X1 $PINS Y=n4969 B=n4650 A=n4649
XU677 NAND2X1 $PINS Y=n4961 B=n4646 A=n4645
XU678 CLKINVX3 $PINS Y=n4440 A=n4448
XU679 CLKBUFX3 $PINS Y=n4443 A=n4448
XU681 INVX3 $PINS Y=n4441 A=n4448
XU685 CLKBUFX3 $PINS Y=n4363 A=n4638
XU686 NOR4X1 $PINS Y=n187 D=N23 C=N24 B=n4426 A=N26
XU687 NOR4X1 $PINS Y=n186 D=N19 C=n4433 B=N21 A=n4422
XU688 CLKINVX1 $PINS Y=n4988 A=ALUOp[2]
XU694 CLKINVX1 $PINS Y=n4955 A=EX_RegWriteData[0]
XU695 CLKINVX1 $PINS Y=n4682 A=EX_RegWriteData[29]
XU696 CLKINVX1 $PINS Y=n4802 A=EX_RegWriteData[17]
XU697 CLKINVX1 $PINS Y=n4793 A=EX_RegWriteData[16]
XU698 CLKINVX1 $PINS Y=n4775 A=EX_RegWriteData[18]
XU699 CLKINVX1 $PINS Y=n4753 A=EX_RegWriteData[20]
XU700 CLKINVX1 $PINS Y=n4744 A=EX_RegWriteData[23]
XU701 CLKINVX1 $PINS Y=n4722 A=EX_RegWriteData[25]
XU702 CLKINVX1 $PINS Y=n4713 A=EX_RegWriteData[24]
XU703 CLKINVX1 $PINS Y=n4704 A=EX_RegWriteData[27]
XU704 CLKINVX1 $PINS Y=n4971 A=EX_RegWriteData[1]
XU705 CLKINVX1 $PINS Y=n4946 A=EX_RegWriteData[3]
XU706 CLKINVX1 $PINS Y=n4937 A=EX_RegWriteData[2]
XU707 CLKINVX1 $PINS Y=n4925 A=EX_RegWriteData[5]
XU708 CLKINVX1 $PINS Y=n4916 A=EX_RegWriteData[4]
XU709 CLKINVX1 $PINS Y=n4907 A=EX_RegWriteData[7]
XU710 CLKINVX1 $PINS Y=n4898 A=EX_RegWriteData[6]
XU711 CLKINVX1 $PINS Y=n4886 A=EX_RegWriteData[9]
XU712 CLKINVX1 $PINS Y=n4877 A=EX_RegWriteData[8]
XU713 CLKINVX1 $PINS Y=n4868 A=EX_RegWriteData[11]
XU714 CLKINVX1 $PINS Y=n4859 A=EX_RegWriteData[10]
XU715 CLKINVX1 $PINS Y=n4846 A=EX_RegWriteData[13]
XU716 CLKINVX1 $PINS Y=n4837 A=EX_RegWriteData[12]
XU717 CLKINVX1 $PINS Y=n4828 A=EX_RegWriteData[15]
XU718 CLKINVX1 $PINS Y=n4819 A=EX_RegWriteData[14]
XU719 CLKINVX1 $PINS Y=n4762 A=EX_RegWriteData[21]
XU720 CLKINVX1 $PINS Y=n4735 A=EX_RegWriteData[22]
XU721 CLKINVX1 $PINS Y=n4695 A=EX_RegWriteData[26]
XU722 CLKINVX1 $PINS Y=n4673 A=EX_RegWriteData[28]
XU723 CLKINVX1 $PINS Y=n4784 A=EX_RegWriteData[19]
XU725 AND2X2 $PINS Y=n105 B=n4574 A=n54
XU726 AND2X2 $PINS Y=n106 B=n4574 A=n66
XU727 AND2X2 $PINS Y=n108 B=n4574 A=n76
XU728 AND2X2 $PINS Y=n109 B=n4574 A=n86
XU729 AND2X2 $PINS Y=n110 B=n4574 A=n97
XU730 AND2X2 $PINS Y=n111 B=n4574 A=n107
XU731 AND2X2 $PINS Y=n112 B=n4574 A=n117
XU732 CLKINVX1 $PINS Y=n4575 A=n132
XU733 CLKBUFX3 $PINS Y=n4303 A=n113
XU735 CLKBUFX3 $PINS Y=n4309 A=n115
XU736 CLKBUFX3 $PINS Y=n4310 A=n115
XU737 CLKBUFX3 $PINS Y=n4311 A=n135
XU738 CLKBUFX3 $PINS Y=n4312 A=n135
XU739 CLKBUFX3 $PINS Y=n4313 A=n126
XU740 CLKBUFX3 $PINS Y=n4314 A=n126
XU741 CLKBUFX3 $PINS Y=n4317 A=n116
XU743 CLKBUFX3 $PINS Y=n4319 A=n136
XU744 CLKBUFX3 $PINS Y=n4320 A=n136
XU745 CLKBUFX3 $PINS Y=n4321 A=n127
XU746 CLKBUFX3 $PINS Y=n4322 A=n127
XU747 CLKBUFX3 $PINS Y=n4325 A=n118
XU748 CLKBUFX3 $PINS Y=n4326 A=n118
XU749 CLKBUFX3 $PINS Y=n4327 A=n137
XU750 CLKBUFX3 $PINS Y=n4328 A=n137
XU751 CLKBUFX3 $PINS Y=n4329 A=n128
XU752 CLKBUFX3 $PINS Y=n4330 A=n128
XU753 CLKBUFX3 $PINS Y=n4333 A=n119
XU755 CLKBUFX3 $PINS Y=n4335 A=n138
XU757 CLKBUFX3 $PINS Y=n4337 A=n129
XU759 CLKBUFX3 $PINS Y=n4341 A=n120
XU761 CLKBUFX3 $PINS Y=n4343 A=n139
XU763 CLKBUFX3 $PINS Y=n4345 A=n130
XU765 CLKBUFX3 $PINS Y=n4349 A=n121
XU767 CLKBUFX3 $PINS Y=n4351 A=n140
XU771 CLKBUFX3 $PINS Y=n4357 A=n122
XU773 CLKBUFX3 $PINS Y=n4359 A=n123
XU775 CLKBUFX3 $PINS Y=n4361 A=n125
XU777 CLKBUFX3 $PINS Y=n4399 A=n4952
XU778 CLKBUFX3 $PINS Y=n4410 A=n4966
XU779 CLKBUFX3 $PINS Y=n4397 A=n4934
XU780 CLKBUFX3 $PINS Y=n4398 A=n4943
XU781 CLKBUFX3 $PINS Y=n4395 A=n4913
XU782 CLKBUFX3 $PINS Y=n4396 A=n4922
XU783 CLKBUFX3 $PINS Y=n4393 A=n4895
XU784 CLKBUFX3 $PINS Y=n4394 A=n4904
XU785 CLKBUFX3 $PINS Y=n4391 A=n4874
XU786 CLKBUFX3 $PINS Y=n4392 A=n4883
XU787 CLKBUFX3 $PINS Y=n4389 A=n4856
XU788 CLKBUFX3 $PINS Y=n4390 A=n4865
XU789 CLKBUFX3 $PINS Y=n4387 A=n4834
XU790 CLKBUFX3 $PINS Y=n4388 A=n4843
XU791 CLKBUFX3 $PINS Y=n4385 A=n4816
XU792 CLKBUFX3 $PINS Y=n4386 A=n4825
XU793 CLKBUFX3 $PINS Y=n4383 A=n4790
XU794 CLKBUFX3 $PINS Y=n4384 A=n4799
XU795 CLKBUFX3 $PINS Y=n4381 A=n4772
XU796 CLKBUFX3 $PINS Y=n4382 A=n4781
XU797 CLKBUFX3 $PINS Y=n4379 A=n4750
XU798 CLKBUFX3 $PINS Y=n4380 A=n4759
XU799 CLKBUFX3 $PINS Y=n4377 A=n4732
XU800 CLKBUFX3 $PINS Y=n4378 A=n4741
XU801 CLKBUFX3 $PINS Y=n4375 A=n4710
XU802 CLKBUFX3 $PINS Y=n4376 A=n4719
XU803 CLKBUFX3 $PINS Y=n4373 A=n4692
XU804 CLKBUFX3 $PINS Y=n4374 A=n4701
XU805 CLKBUFX3 $PINS Y=n4371 A=n4670
XU806 CLKBUFX3 $PINS Y=n4372 A=n4679
XU807 CLKBUFX3 $PINS Y=n4369 A=n4652
XU808 CLKBUFX3 $PINS Y=n4370 A=n4661
XU809 CLKBUFX3 $PINS Y=n4305 A=n114
XU811 NAND2X1 $PINS Y=n4965 B=n4650 A=BrForwardB[1]
XU812 NAND2X1 $PINS Y=n4958 B=n4646 A=BrForwardA[1]
XU813 NAND2X1 $PINS Y=n4967 B=BrForwardB[0] A=BrForwardB[1]
XU814 NAND2X1 $PINS Y=n4959 B=BrForwardA[0] A=BrForwardA[1]
XU815 NAND2X1 $PINS Y=n4972 B=n4649 A=BrForwardB[0]
XU816 NAND2X1 $PINS Y=n4963 B=n4645 A=BrForwardA[0]
XU817 CLKINVX1 $PINS Y=n4650 A=BrForwardB[0]
XU818 CLKINVX1 $PINS Y=n4646 A=BrForwardA[0]
XU819 CLKINVX1 $PINS Y=n4649 A=BrForwardB[1]
XU820 CLKINVX1 $PINS Y=n4645 A=BrForwardA[1]
XU824 INVX3 $PINS Y=n4429 A=n4430
XU825 INVX3 $PINS Y=n4426 A=n4427
XU826 CLKINVX1 $PINS Y=n4433 A=n4434
XU827 CLKINVX1 $PINS Y=n4987 A=Branch
XU828 CLKBUFX3 $PINS Y=n4364 A=n4640
XU832 OA22X1 $PINS Y=n4791 B1=n4789 B0=FE_OFN179_n4408 A1=n4790 A0=n4411
XU833 CLKINVX1 $PINS Y=n4792 A=next_RData2[16]
XU834 OA22X1 $PINS Y=n4782 B1=n4780 B0=FE_OFN179_n4408 A1=n4781 A0=n4411
XU835 CLKINVX1 $PINS Y=n4783 A=next_RData2[19]
XU836 OA22X1 $PINS Y=n4773 B1=n4771 B0=FE_OFN179_n4408 A1=n4772 A0=n4411
XU837 CLKINVX1 $PINS Y=n4774 A=next_RData2[18]
XU838 OA22X1 $PINS Y=n4751 B1=n4749 B0=FE_OFN179_n4408 A1=n4750 A0=n4411
XU839 OA22X1 $PINS Y=n4742 B1=n4740 B0=FE_OFN179_n4408 A1=n4741 A0=n4411
XU840 CLKINVX1 $PINS Y=n4743 A=next_RData2[23]
XU841 OA22X1 $PINS Y=n4733 B1=n4731 B0=FE_OFN179_n4408 A1=n4732 A0=n4411
XU842 CLKINVX1 $PINS Y=n4734 A=next_RData2[22]
XU843 OA22X1 $PINS Y=n4711 B1=n4709 B0=FE_OFN179_n4408 A1=n4710 A0=n4411
XU844 CLKINVX1 $PINS Y=n4712 A=next_RData2[24]
XU845 OA22X1 $PINS Y=n4702 B1=n4700 B0=FE_OFN179_n4408 A1=n4701
+ A0=FE_OFN180_n4411
XU846 CLKINVX1 $PINS Y=n4703 A=next_RData2[27]
XU847 OA22X1 $PINS Y=n4693 B1=n4691 B0=FE_OFN179_n4408 A1=n4692
+ A0=FE_OFN180_n4411
XU848 CLKINVX1 $PINS Y=n4694 A=next_RData2[26]
XU849 OA22X1 $PINS Y=n4671 B1=n4669 B0=FE_OFN179_n4408 A1=n4670
+ A0=FE_OFN180_n4411
XU850 CLKINVX1 $PINS Y=n4672 A=next_RData2[28]
XU851 OA22X1 $PINS Y=n4662 B1=n4660 B0=FE_OFN179_n4408 A1=n4661
+ A0=FE_OFN180_n4411
XU852 CLKINVX1 $PINS Y=n4663 A=next_RData2[31]
XU853 OA22X1 $PINS Y=n4653 B1=n4651 B0=FE_OFN179_n4408 A1=n4652
+ A0=FE_OFN180_n4411
XU854 CLKINVX1 $PINS Y=n4654 A=next_RData2[30]
XU855 OA22X1 $PINS Y=n4953 B1=n4951 B0=FE_OFN179_n4408 A1=n4952
+ A0=FE_OFN180_n4411
XU856 OA22X1 $PINS Y=n4944 B1=n4942 B0=n4965 A1=n4943 A0=FE_OFN180_n4411
XU857 CLKINVX1 $PINS Y=n4945 A=next_RData2[3]
XU858 OA22X1 $PINS Y=n4935 B1=n4933 B0=n4408 A1=n4934 A0=FE_OFN180_n4411
XU859 OA22X1 $PINS Y=n4914 B1=n4912 B0=n4965 A1=n4913 A0=FE_OFN180_n4411
XU860 CLKINVX1 $PINS Y=n4915 A=next_RData2[4]
XU861 OA22X1 $PINS Y=n4905 B1=n4903 B0=n4965 A1=n4904 A0=FE_OFN180_n4411
XU862 CLKINVX1 $PINS Y=n4906 A=next_RData2[7]
XU863 OA22X1 $PINS Y=n4896 B1=n4894 B0=n4408 A1=n4895 A0=FE_OFN180_n4411
XU864 CLKINVX1 $PINS Y=n4897 A=next_RData2[6]
XU865 OA22X1 $PINS Y=n4875 B1=n4873 B0=n4408 A1=n4874 A0=n4967
XU866 CLKINVX1 $PINS Y=n4876 A=next_RData2[8]
XU867 OA22X1 $PINS Y=n4866 B1=n4864 B0=n4408 A1=n4865 A0=n4967
XU868 CLKINVX1 $PINS Y=n4867 A=next_RData2[11]
XU869 OA22X1 $PINS Y=n4857 B1=n4855 B0=n4408 A1=n4856 A0=FE_OFN180_n4411
XU870 CLKINVX1 $PINS Y=n4858 A=next_RData2[10]
XU871 OA22X1 $PINS Y=n4835 B1=n4833 B0=n4408 A1=n4834 A0=n4967
XU872 CLKINVX1 $PINS Y=n4836 A=next_RData2[12]
XU873 OA22X1 $PINS Y=n4826 B1=n4824 B0=n4408 A1=n4825 A0=n4967
XU874 CLKINVX1 $PINS Y=n4827 A=next_RData2[15]
XU875 OA22X1 $PINS Y=n4817 B1=n4815 B0=n4408 A1=n4816 A0=n4411
XU876 CLKINVX1 $PINS Y=n4818 A=next_RData2[14]
XU877 OA22X1 $PINS Y=n4787 B1=n4789 B0=FE_OFN177_n4400 A1=n4790 A0=n4402
XU878 CLKINVX1 $PINS Y=n4788 A=next_RData1[16]
XU880 OA22X1 $PINS Y=n4769 B1=n4771 B0=FE_OFN177_n4400 A1=n4772 A0=n4402
XU881 CLKINVX1 $PINS Y=n4770 A=next_RData1[18]
XU882 OA22X1 $PINS Y=n4747 B1=n4749 B0=FE_OFN177_n4400 A1=n4750 A0=n4402
XU888 OA22X1 $PINS Y=n4707 B1=n4709 B0=FE_OFN177_n4400 A1=n4710 A0=n4402
XU889 CLKINVX1 $PINS Y=n4708 A=next_RData1[24]
XU890 OA22X1 $PINS Y=n4698 B1=n4700 B0=FE_OFN177_n4400 A1=n4701 A0=n4402
XU891 CLKINVX1 $PINS Y=n4699 A=next_RData1[27]
XU892 OA22X1 $PINS Y=n4689 B1=n4691 B0=n4958 A1=n4692 A0=FE_OFN178_n4402
XU893 CLKINVX1 $PINS Y=n4690 A=next_RData1[26]
XU896 OA22X1 $PINS Y=n4658 B1=n4660 B0=n4958 A1=n4661 A0=FE_OFN178_n4402
XU897 CLKINVX1 $PINS Y=n4659 A=next_RData1[31]
XU898 OA22X1 $PINS Y=n4647 B1=n4651 B0=FE_OFN177_n4400 A1=n4652
+ A0=FE_OFN178_n4402
XU899 CLKINVX1 $PINS Y=n4648 A=next_RData1[30]
XU900 OA22X1 $PINS Y=n4949 B1=n4951 B0=n4400 A1=n4952 A0=FE_OFN178_n4402
XU901 CLKINVX1 $PINS Y=n4950 A=next_RData1[0]
XU902 OA22X1 $PINS Y=n4940 B1=n4942 B0=n4400 A1=n4943 A0=FE_OFN178_n4402
XU903 OA22X1 $PINS Y=n4931 B1=n4933 B0=FE_OFN177_n4400 A1=n4934
+ A0=FE_OFN178_n4402
XU904 OA22X1 $PINS Y=n4910 B1=n4912 B0=n4400 A1=n4913 A0=FE_OFN178_n4402
XU905 OA22X1 $PINS Y=n4901 B1=n4903 B0=n4400 A1=n4904 A0=FE_OFN178_n4402
XU907 OA22X1 $PINS Y=n4892 B1=n4894 B0=n4400 A1=n4895 A0=FE_OFN178_n4402
XU908 CLKINVX1 $PINS Y=n4893 A=next_RData1[6]
XU909 OA22X1 $PINS Y=n4871 B1=n4873 B0=n4400 A1=n4874 A0=FE_OFN178_n4402
XU910 CLKINVX1 $PINS Y=n4872 A=next_RData1[8]
XU911 OA22X1 $PINS Y=n4862 B1=n4864 B0=n4400 A1=n4865 A0=FE_OFN178_n4402
XU912 CLKINVX1 $PINS Y=n4863 A=next_RData1[11]
XU913 OA22X1 $PINS Y=n4853 B1=n4855 B0=n4400 A1=n4856 A0=FE_OFN178_n4402
XU914 CLKINVX1 $PINS Y=n4854 A=next_RData1[10]
XU915 OA22X1 $PINS Y=n4831 B1=n4833 B0=n4400 A1=n4834 A0=n4959
XU917 OA22X1 $PINS Y=n4822 B1=n4824 B0=n4400 A1=n4825 A0=n4959
XU918 OA22X1 $PINS Y=n4813 B1=n4815 B0=n4400 A1=n4816 A0=n4959
XU921 OA22X1 $PINS Y=n4756 B1=n4758 B0=FE_OFN177_n4400 A1=n4759 A0=n4402
XU922 OA22X1 $PINS Y=n4716 B1=n4718 B0=FE_OFN177_n4400 A1=n4719 A0=n4402
XU923 OA22X1 $PINS Y=n4676 B1=n4678 B0=FE_OFN177_n4400 A1=n4679
+ A0=FE_OFN178_n4402
XU924 XNOR2X1 $PINS Y=n4975 B=n4973 A=n4974
XU925 OA22X1 $PINS Y=n4960 B1=n4964 B0=FE_OFN177_n4400 A1=n4966 A0=n4959
XU926 OA22X1 $PINS Y=n4919 B1=n4921 B0=n4400 A1=n4922 A0=FE_OFN178_n4402
XU927 OA22X1 $PINS Y=n4880 B1=n4882 B0=n4400 A1=n4883 A0=FE_OFN178_n4402
XU928 OA22X1 $PINS Y=n4840 B1=n4842 B0=n4400 A1=n4843 A0=n4959
XU932 CLKINVX1 $PINS Y=n4920 A=next_RData1[5]
XU933 CLKINVX1 $PINS Y=n4881 A=next_RData1[9]
XU934 CLKINVX1 $PINS Y=n4841 A=next_RData1[13]
XU935 CLKINVX1 $PINS Y=n4801 A=next_RData2[17]
XU936 CLKINVX1 $PINS Y=n4721 A=next_RData2[25]
XU937 CLKINVX1 $PINS Y=n4681 A=next_RData2[29]
XU938 CLKINVX1 $PINS Y=n4924 A=next_RData2[5]
XU939 CLKINVX1 $PINS Y=n4885 A=next_RData2[9]
XU940 CLKINVX1 $PINS Y=n4845 A=next_RData2[13]
XU941 NAND3BX1 $PINS Y=n4644 C=n4983 B=FE_OFN204_n4420 AN=n4419
XU942 CLKINVX1 $PINS Y=n4664 A=EX_RegWriteData[31]
XU943 NAND2X1 $PINS Y=n132 B=n93 A=n104
XU944 CLKBUFX3 $PINS Y=n4420 A=n191
XU945 CLKINVX1 $PINS Y=n4417 A=n4419
XU947 AND2X2 $PINS Y=n113 B=n53 A=n54
XU948 AND2X2 $PINS Y=n114 B=n57 A=n54
XU949 AND2X2 $PINS Y=n115 B=n65 A=n66
XU950 AND2X2 $PINS Y=n116 B=n65 A=n76
XU951 AND2X2 $PINS Y=n118 B=n65 A=n86
XU952 AND2X2 $PINS Y=n119 B=n65 A=n97
XU953 AND2X2 $PINS Y=n120 B=n65 A=n107
XU954 AND2X2 $PINS Y=n121 B=n65 A=n117
XU955 AND2X2 $PINS Y=n122 B=n4575 A=n65
XU956 AND2X2 $PINS Y=n123 B=n4575 A=n53
XU957 AND2X2 $PINS Y=n125 B=n4575 A=n57
XU958 AND2X2 $PINS Y=n126 B=n57 A=n66
XU959 AND2X2 $PINS Y=n127 B=n57 A=n76
XU960 AND2X2 $PINS Y=n128 B=n57 A=n86
XU961 AND2X2 $PINS Y=n129 B=n57 A=n97
XU962 AND2X2 $PINS Y=n130 B=n57 A=n107
XU963 AND2X2 $PINS Y=n131 B=n57 A=n117
XU964 AND2X2 $PINS Y=n135 B=n53 A=n66
XU965 AND2X2 $PINS Y=n136 B=n53 A=n76
XU966 AND2X2 $PINS Y=n137 B=n53 A=n86
XU967 AND2X2 $PINS Y=n138 B=n53 A=n97
XU968 AND2X2 $PINS Y=n139 B=n53 A=n107
XU969 AND2X2 $PINS Y=n140 B=n53 A=n117
XU970 AND2X2 $PINS Y=n117 B=n83 A=n104
XU971 AND2X2 $PINS Y=n66 B=n61 A=n73
XU972 AND2X2 $PINS Y=n76 B=n61 A=n83
XU973 AND2X2 $PINS Y=n86 B=n61 A=n93
XU974 AND2X2 $PINS Y=n97 B=n62 A=n104
XU975 AND2X2 $PINS Y=n107 B=n73 A=n104
XU976 AND2X2 $PINS Y=n54 B=n62 A=n61
XU979 OA22X1 $PINS Y=n4800 B1=n4798 B0=FE_OFN179_n4408 A1=n4799 A0=n4411
XU980 OA22X1 $PINS Y=n4760 B1=n4758 B0=FE_OFN179_n4408 A1=n4759 A0=n4411
XU981 OA22X1 $PINS Y=n4720 B1=n4718 B0=FE_OFN179_n4408 A1=n4719 A0=n4411
XU982 OA22X1 $PINS Y=n4680 B1=n4678 B0=FE_OFN179_n4408 A1=n4679
+ A0=FE_OFN180_n4411
XU983 OA22X1 $PINS Y=n4968 B1=n4964 B0=n4408 A1=n4966 A0=FE_OFN180_n4411
XU984 OA22X1 $PINS Y=n4923 B1=n4921 B0=n4408 A1=n4922 A0=FE_OFN180_n4411
XU985 OA22X1 $PINS Y=n4884 B1=n4882 B0=n4408 A1=n4883 A0=FE_OFN180_n4411
XU986 OA22X1 $PINS Y=n4844 B1=n4842 B0=n4408 A1=n4843 A0=n4967
XU987 CLKINVX1 $PINS Y=n4985 A=n172
XU988 NOR2X1 $PINS Y=n181 B=Bubble A=n4438
XU989 OR2X1 $PINS Y=n134 B=n4437 A=n167
XU990 CLKINVX1 $PINS Y=n4986 A=ALUOp[0]
XU991 CLKBUFX3 $PINS Y=n4449 A=rst
XU992 OAI32X1 $PINS Y=PredictMiss B1=n4982 B0=BranchTaken A2=equal A1=n4987
+ A0=n4989
XU993 MX4X1 $PINS Y=n156 S1=n3738 S0=n3733 D=n244 C=n246 B=n245 A=n247
XU994 MX4X1 $PINS Y=n160 S1=n3738 S0=n3734 D=n260 C=n262 B=n261 A=n263
XU995 MX4X1 $PINS Y=n162 S1=n3738 S0=n3734 D=n268 C=n270 B=n269 A=n271
XU996 MX4X1 $PINS Y=n164 S1=n3738 S0=n3734 D=n276 C=n278 B=n277 A=n279
XU999 MX4X1 $PINS Y=n173 S1=n3738 S0=n3734 D=n292 C=n294 B=n293 A=n295
XU1000 MX4X1 $PINS Y=n175 S1=n3738 S0=n3734 D=n300 C=n302 B=n301 A=n303
XU1001 MX4X1 $PINS Y=n197 S1=n3739 S0=N20 D=n332 C=n334 B=n333 A=n335
XU1002 MX4X1 $PINS Y=n199 S1=n3739 S0=N20 D=n340 C=n342 B=n341 A=n343
XU1003 MX4X1 $PINS Y=n203 S1=N19 S0=n3735 D=n356 C=n358 B=n357 A=n359
XU1004 MXI2X1 $PINS Y=N132 S0=N21 B=n206 A=n205
XU1005 MX4X1 $PINS Y=n213 S1=N19 S0=n3735 D=n396 C=n398 B=n397 A=n399
XU1006 MX4X1 $PINS Y=n219 S1=N19 S0=n3736 D=n420 C=n422 B=n421 A=n423
XU1007 MX4X1 $PINS Y=n207 S1=N19 S0=n3735 D=n372 C=n374 B=n373 A=n375
XU1008 MX4X1 $PINS Y=n228 S1=n3740 S0=n3737 D=n452 C=n454 B=n453 A=n455
XU1009 MX4X1 $PINS Y=n236 S1=n3740 S0=n3737 D=n484 C=n486 B=n485 A=n487
XU1010 MX4X1 $PINS Y=n238 S1=n3740 S0=n3737 D=n492 C=n494 B=n493 A=n495
XU1011 MX4X1 $PINS Y=n3782 S1=n4262 S0=n4259 D=n3857 C=n3859 B=n3858 A=n3860
XU1012 MXI4X1 $PINS Y=n3860 S1=n4278 S0=n4291 D=regfile[19][2] C=regfile[18][2]
+ B=regfile[17][2] A=regfile[16][2]
XU1013 MXI4X1 $PINS Y=n3858 S1=n4276 S0=n4291 D=regfile[27][2] C=regfile[26][2]
+ B=regfile[25][2] A=regfile[24][2]
XU1014 MXI4X1 $PINS Y=n3857 S1=n4279 S0=n4291 D=regfile[31][2] C=regfile[30][2]
+ B=regfile[29][2] A=regfile[28][2]
XU1015 MX4X1 $PINS Y=n3784 S1=n4262 S0=n4259 D=n3865 C=n3867 B=n3866 A=n3868
XU1016 MXI4X1 $PINS Y=n3868 S1=FE_OFN213_n4271 S0=n4292 D=regfile[19][3]
+ C=regfile[18][3] B=regfile[17][3] A=regfile[16][3]
XU1017 MXI4X1 $PINS Y=n3866 S1=n4271 S0=n4291 D=regfile[27][3] C=regfile[26][3]
+ B=regfile[25][3] A=regfile[24][3]
XU1018 MXI4X1 $PINS Y=n3865 S1=FE_OFN213_n4271 S0=n4291 D=regfile[31][3]
+ C=regfile[30][3] B=regfile[29][3] A=regfile[28][3]
XU1019 MX4X1 $PINS Y=n3786 S1=n4262 S0=n4259 D=n3873 C=n3875 B=n3874 A=n3876
XU1020 MXI4X1 $PINS Y=n3876 S1=FE_OFN213_n4271 S0=n4292 D=regfile[19][4]
+ C=regfile[18][4] B=regfile[17][4] A=regfile[16][4]
XU1021 MXI4X1 $PINS Y=n3874 S1=FE_OFN213_n4271 S0=n4292 D=regfile[27][4]
+ C=regfile[26][4] B=regfile[25][4] A=regfile[24][4]
XU1022 MXI4X1 $PINS Y=n3873 S1=FE_OFN213_n4271 S0=n4292 D=regfile[31][4]
+ C=regfile[30][4] B=regfile[29][4] A=regfile[28][4]
XU1023 MX4X1 $PINS Y=n3788 S1=n4262 S0=n4259 D=n3881 C=n3883 B=n3882 A=n3884
XU1024 MXI4X1 $PINS Y=n3884 S1=FE_OFN213_n4271 S0=n4292 D=regfile[19][5]
+ C=regfile[18][5] B=regfile[17][5] A=regfile[16][5]
XU1025 MXI4X1 $PINS Y=n3882 S1=FE_OFN213_n4271 S0=n4292 D=regfile[27][5]
+ C=regfile[26][5] B=regfile[25][5] A=regfile[24][5]
XU1026 MXI4X1 $PINS Y=n3881 S1=FE_OFN213_n4271 S0=n4292 D=regfile[31][5]
+ C=regfile[30][5] B=regfile[29][5] A=regfile[28][5]
XU1027 MX4X1 $PINS Y=n3790 S1=n4262 S0=n4259 D=n3889 C=n3891 B=n3890 A=n3892
XU1028 MXI4X1 $PINS Y=n3892 S1=FE_OFN215_n4272 S0=n4293 D=regfile[19][6]
+ C=regfile[18][6] B=regfile[17][6] A=regfile[16][6]
XU1029 MXI4X1 $PINS Y=n3890 S1=FE_OFN215_n4272 S0=n4293 D=regfile[27][6]
+ C=regfile[26][6] B=regfile[25][6] A=regfile[24][6]
XU1030 MXI4X1 $PINS Y=n3889 S1=FE_OFN213_n4271 S0=n4293 D=regfile[31][6]
+ C=regfile[30][6] B=regfile[29][6] A=regfile[28][6]
XU1031 MX4X1 $PINS Y=n3792 S1=n4262 S0=n4259 D=n3897 C=n3899 B=n3898 A=n3900
XU1032 MXI4X1 $PINS Y=n3900 S1=FE_OFN215_n4272 S0=n4293 D=regfile[19][7]
+ C=regfile[18][7] B=regfile[17][7] A=regfile[16][7]
XU1033 MXI4X1 $PINS Y=n3898 S1=FE_OFN215_n4272 S0=n4293 D=regfile[27][7]
+ C=regfile[26][7] B=regfile[25][7] A=regfile[24][7]
XU1034 MXI4X1 $PINS Y=n3897 S1=FE_OFN215_n4272 S0=n4293 D=regfile[31][7]
+ C=regfile[30][7] B=regfile[29][7] A=regfile[28][7]
XU1035 MX4X1 $PINS Y=n3794 S1=N24 S0=N25 D=n3905 C=n3907 B=n3906 A=n3908
XU1036 MXI4X1 $PINS Y=n3908 S1=FE_OFN215_n4272 S0=n4294 D=regfile[19][8]
+ C=regfile[18][8] B=regfile[17][8] A=regfile[16][8]
XU1037 MXI4X1 $PINS Y=n3906 S1=FE_OFN215_n4272 S0=n4294 D=regfile[27][8]
+ C=regfile[26][8] B=regfile[25][8] A=regfile[24][8]
XU1038 MXI4X1 $PINS Y=n3905 S1=n4275 S0=n4297 D=regfile[31][8] C=regfile[30][8]
+ B=regfile[29][8] A=regfile[28][8]
XU1039 MX4X1 $PINS Y=n3796 S1=n4264 S0=N25 D=n3913 C=n3915 B=n3914 A=n3916
XU1040 MXI4X1 $PINS Y=n3916 S1=FE_OFN214_n4273 S0=n4294 D=regfile[19][9]
+ C=regfile[18][9] B=regfile[17][9] A=regfile[16][9]
XU1041 MXI4X1 $PINS Y=n3914 S1=FE_OFN214_n4273 S0=n4294 D=regfile[27][9]
+ C=regfile[26][9] B=regfile[25][9] A=regfile[24][9]
XU1042 MXI4X1 $PINS Y=n3913 S1=FE_OFN215_n4272 S0=n4294 D=regfile[31][9]
+ C=regfile[30][9] B=regfile[29][9] A=regfile[28][9]
XU1044 MXI4X1 $PINS Y=n3924 S1=n4273 S0=n4295 D=regfile[19][10]
+ C=regfile[18][10] B=regfile[17][10] A=regfile[16][10]
XU1045 MXI4X1 $PINS Y=n3922 S1=n4273 S0=n4295 D=regfile[27][10]
+ C=regfile[26][10] B=regfile[25][10] A=regfile[24][10]
XU1046 MXI4X1 $PINS Y=n3921 S1=FE_OFN214_n4273 S0=n4295 D=regfile[31][10]
+ C=regfile[30][10] B=regfile[29][10] A=regfile[28][10]
XU1047 MX4X1 $PINS Y=n3800 S1=N24 S0=N25 D=n3929 C=n3931 B=n3930 A=n3932
XU1048 MXI4X1 $PINS Y=n3932 S1=FE_OFN214_n4273 S0=n4295 D=regfile[19][11]
+ C=regfile[18][11] B=regfile[17][11] A=regfile[16][11]
XU1049 MXI4X1 $PINS Y=n3930 S1=FE_OFN214_n4273 S0=n4295 D=regfile[27][11]
+ C=regfile[26][11] B=regfile[25][11] A=regfile[24][11]
XU1050 MXI4X1 $PINS Y=n3929 S1=FE_OFN214_n4273 S0=n4295 D=regfile[31][11]
+ C=regfile[30][11] B=regfile[29][11] A=regfile[28][11]
XU1052 MXI4X1 $PINS Y=n3940 S1=n4266 S0=n4296 D=regfile[19][12]
+ C=regfile[18][12] B=regfile[17][12] A=regfile[16][12]
XU1053 MXI4X1 $PINS Y=n3938 S1=n4273 S0=n4296 D=regfile[27][12]
+ C=regfile[26][12] B=regfile[25][12] A=regfile[24][12]
XU1054 MXI4X1 $PINS Y=n3937 S1=n4273 S0=n4296 D=regfile[31][12]
+ C=regfile[30][12] B=regfile[29][12] A=regfile[28][12]
XU1055 MX4X1 $PINS Y=n3804 S1=N24 S0=N25 D=n3945 C=n3947 B=n3946 A=n3948
XU1056 MXI4X1 $PINS Y=n3948 S1=n4272 S0=n4296 D=regfile[19][13]
+ C=regfile[18][13] B=regfile[17][13] A=regfile[16][13]
XU1057 MXI4X1 $PINS Y=n3946 S1=n4276 S0=n4296 D=regfile[27][13]
+ C=regfile[26][13] B=regfile[25][13] A=regfile[24][13]
XU1058 MXI4X1 $PINS Y=n3945 S1=n4274 S0=n4296 D=regfile[31][13]
+ C=regfile[30][13] B=regfile[29][13] A=regfile[28][13]
XU1059 MX4X1 $PINS Y=n3806 S1=n4263 S0=N25 D=n3953 C=n3955 B=n3954 A=n3956
XU1060 MXI4X1 $PINS Y=n3956 S1=n4268 S0=n4297 D=regfile[19][14]
+ C=regfile[18][14] B=regfile[17][14] A=regfile[16][14]
XU1061 MXI4X1 $PINS Y=n3954 S1=FE_OFN216_n4267 S0=n4297 D=regfile[27][14]
+ C=regfile[26][14] B=regfile[25][14] A=regfile[24][14]
XU1062 MXI4X1 $PINS Y=n3953 S1=n4280 S0=n4296 D=regfile[31][14]
+ C=regfile[30][14] B=regfile[29][14] A=regfile[28][14]
XU1063 MX4X1 $PINS Y=n3808 S1=n4263 S0=N25 D=n3961 C=n3963 B=n3962 A=n3964
XU1064 MXI4X1 $PINS Y=n3964 S1=n4273 S0=n4297 D=regfile[19][15]
+ C=regfile[18][15] B=regfile[17][15] A=regfile[16][15]
XU1065 MXI4X1 $PINS Y=n3962 S1=n4272 S0=n4297 D=regfile[27][15]
+ C=regfile[26][15] B=regfile[25][15] A=regfile[24][15]
XU1066 MXI4X1 $PINS Y=n3961 S1=n4266 S0=n4297 D=regfile[31][15]
+ C=regfile[30][15] B=regfile[29][15] A=regfile[28][15]
XU1067 MX4X1 $PINS Y=n3810 S1=n4263 S0=N25 D=n3969 C=n3971 B=n3970 A=n3972
XU1068 MXI4X1 $PINS Y=n3972 S1=n4269 S0=n4283 D=regfile[19][16]
+ C=regfile[18][16] B=regfile[17][16] A=regfile[16][16]
XU1069 MXI4X1 $PINS Y=n3970 S1=n4270 S0=n4283 D=regfile[27][16]
+ C=regfile[26][16] B=regfile[25][16] A=regfile[24][16]
XU1070 MXI4X1 $PINS Y=n3969 S1=n4275 S0=n4283 D=regfile[31][16]
+ C=regfile[30][16] B=regfile[29][16] A=regfile[28][16]
XU1071 MX4X1 $PINS Y=n3812 S1=n4263 S0=N25 D=n3977 C=n3979 B=n3978 A=n3980
XU1072 MXI4X1 $PINS Y=n3980 S1=n4280 S0=n4283 D=regfile[19][17]
+ C=regfile[18][17] B=regfile[17][17] A=regfile[16][17]
XU1073 MXI4X1 $PINS Y=n3978 S1=n4270 S0=n4283 D=regfile[27][17]
+ C=regfile[26][17] B=regfile[25][17] A=regfile[24][17]
XU1074 MXI4X1 $PINS Y=n3977 S1=n4268 S0=n4283 D=regfile[31][17]
+ C=regfile[30][17] B=regfile[29][17] A=regfile[28][17]
XU1075 MX4X1 $PINS Y=n3814 S1=n4263 S0=N25 D=n3985 C=n3987 B=n3986 A=n3988
XU1076 MXI4X1 $PINS Y=n3988 S1=n4278 S0=n4284 D=regfile[19][18]
+ C=regfile[18][18] B=regfile[17][18] A=regfile[16][18]
XU1077 MXI4X1 $PINS Y=n3986 S1=n4279 S0=n4284 D=regfile[27][18]
+ C=regfile[26][18] B=regfile[25][18] A=regfile[24][18]
XU1078 MXI4X1 $PINS Y=n3985 S1=n4280 S0=n4283 D=regfile[31][18]
+ C=regfile[30][18] B=regfile[29][18] A=regfile[28][18]
XU1079 MX4X1 $PINS Y=n3816 S1=n4263 S0=N25 D=n3993 C=n3995 B=n3994 A=n3996
XU1080 MXI4X1 $PINS Y=n3996 S1=n4276 S0=n4284 D=regfile[19][19]
+ C=regfile[18][19] B=regfile[17][19] A=regfile[16][19]
XU1081 MXI4X1 $PINS Y=n3994 S1=n4277 S0=n4284 D=regfile[27][19]
+ C=regfile[26][19] B=regfile[25][19] A=regfile[24][19]
XU1082 MXI4X1 $PINS Y=n3993 S1=n4275 S0=n4284 D=regfile[31][19]
+ C=regfile[30][19] B=regfile[29][19] A=regfile[28][19]
XU1084 MXI4X1 $PINS Y=n4004 S1=FE_OFN216_n4267 S0=n4285 D=regfile[19][20]
+ C=regfile[18][20] B=regfile[17][20] A=regfile[16][20]
XU1085 MXI4X1 $PINS Y=n4002 S1=FE_OFN216_n4267 S0=n4284 D=regfile[27][20]
+ C=regfile[26][20] B=regfile[25][20] A=regfile[24][20]
XU1086 MXI4X1 $PINS Y=n4001 S1=FE_OFN216_n4267 S0=n4284 D=regfile[31][20]
+ C=regfile[30][20] B=regfile[29][20] A=regfile[28][20]
XU1088 MXI4X1 $PINS Y=n4012 S1=n4266 S0=n4285 D=regfile[19][21]
+ C=regfile[18][21] B=regfile[17][21] A=regfile[16][21]
XU1089 MXI4X1 $PINS Y=n4010 S1=FE_OFN216_n4267 S0=n4285 D=regfile[27][21]
+ C=regfile[26][21] B=regfile[25][21] A=regfile[24][21]
XU1090 MXI4X1 $PINS Y=n4009 S1=n4266 S0=n4285 D=regfile[31][21]
+ C=regfile[30][21] B=regfile[29][21] A=regfile[28][21]
XU1091 MX4X1 $PINS Y=n3822 S1=n4264 S0=n4261 D=n4017 C=n4019 B=n4018 A=n4020
XU1092 MXI4X1 $PINS Y=n4020 S1=n4279 S0=n4286 D=regfile[19][22]
+ C=regfile[18][22] B=regfile[17][22] A=regfile[16][22]
XU1093 MXI4X1 $PINS Y=n4018 S1=n4276 S0=n4285 D=regfile[27][22]
+ C=regfile[26][22] B=regfile[25][22] A=regfile[24][22]
XU1094 MXI4X1 $PINS Y=n4017 S1=n4276 S0=n4285 D=regfile[31][22]
+ C=regfile[30][22] B=regfile[29][22] A=regfile[28][22]
XU1095 MX4X1 $PINS Y=n3824 S1=n4264 S0=n4261 D=n4025 C=n4027 B=n4026 A=n4028
XU1096 MXI4X1 $PINS Y=n4028 S1=n4268 S0=n4286 D=regfile[19][23]
+ C=regfile[18][23] B=regfile[17][23] A=regfile[16][23]
XU1097 MXI4X1 $PINS Y=n4026 S1=n4275 S0=n4286 D=regfile[27][23]
+ C=regfile[26][23] B=regfile[25][23] A=regfile[24][23]
XU1098 MXI4X1 $PINS Y=n4025 S1=n4276 S0=n4286 D=regfile[31][23]
+ C=regfile[30][23] B=regfile[29][23] A=regfile[28][23]
XU1099 MX4X1 $PINS Y=n3826 S1=n4264 S0=n4261 D=n4033 C=n4035 B=n4034 A=n4036
XU1100 MXI4X1 $PINS Y=n4036 S1=n4269 S0=n4287 D=regfile[19][24]
+ C=regfile[18][24] B=regfile[17][24] A=regfile[16][24]
XU1101 MXI4X1 $PINS Y=n4034 S1=n4279 S0=n4286 D=regfile[27][24]
+ C=regfile[26][24] B=regfile[25][24] A=regfile[24][24]
XU1102 MXI4X1 $PINS Y=n4033 S1=n4280 S0=n4286 D=regfile[31][24]
+ C=regfile[30][24] B=regfile[29][24] A=regfile[28][24]
XU1103 MX4X1 $PINS Y=n3828 S1=n4264 S0=n4261 D=n4041 C=n4043 B=n4042 A=n4044
XU1104 MXI4X1 $PINS Y=n4044 S1=n4280 S0=n4287 D=regfile[19][25]
+ C=regfile[18][25] B=regfile[17][25] A=regfile[16][25]
XU1105 MXI4X1 $PINS Y=n4042 S1=n4276 S0=n4287 D=regfile[27][25]
+ C=regfile[26][25] B=regfile[25][25] A=regfile[24][25]
XU1106 MXI4X1 $PINS Y=n4041 S1=n4275 S0=n4287 D=regfile[31][25]
+ C=regfile[30][25] B=regfile[29][25] A=regfile[28][25]
XU1107 MX4X1 $PINS Y=n3830 S1=n4265 S0=N25 D=n4049 C=n4051 B=n4050 A=n4052
XU1108 MXI4X1 $PINS Y=n4052 S1=FE_OFN216_n4267 S0=n4287 D=regfile[19][26]
+ C=regfile[18][26] B=regfile[17][26] A=regfile[16][26]
XU1109 MXI4X1 $PINS Y=n4050 S1=n4267 S0=n4287 D=regfile[27][26]
+ C=regfile[26][26] B=regfile[25][26] A=regfile[24][26]
XU1110 MXI4X1 $PINS Y=n4049 S1=FE_OFN216_n4267 S0=n4287 D=regfile[31][26]
+ C=regfile[30][26] B=regfile[29][26] A=regfile[28][26]
XU1111 MX4X1 $PINS Y=n3832 S1=n4265 S0=n4258 D=n4057 C=n4059 B=n4058 A=n4060
XU1112 MXI4X1 $PINS Y=n4060 S1=n4267 S0=n4288 D=regfile[19][27]
+ C=regfile[18][27] B=regfile[17][27] A=regfile[16][27]
XU1113 MXI4X1 $PINS Y=n4058 S1=n4267 S0=n4288 D=regfile[27][27]
+ C=regfile[26][27] B=regfile[25][27] A=regfile[24][27]
XU1114 MXI4X1 $PINS Y=n4057 S1=n4276 S0=n4288 D=regfile[31][27]
+ C=regfile[30][27] B=regfile[29][27] A=regfile[28][27]
XU1115 MX4X1 $PINS Y=n3834 S1=n4265 S0=n4426 D=n4065 C=n4067 B=n4066 A=n4068
XU1116 MXI4X1 $PINS Y=n4068 S1=n4280 S0=n4288 D=regfile[19][28]
+ C=regfile[18][28] B=regfile[17][28] A=regfile[16][28]
XU1117 MXI4X1 $PINS Y=n4066 S1=n4275 S0=n4288 D=regfile[27][28]
+ C=regfile[26][28] B=regfile[25][28] A=regfile[24][28]
XU1118 MXI4X1 $PINS Y=n4065 S1=n4275 S0=n4288 D=regfile[31][28]
+ C=regfile[30][28] B=regfile[29][28] A=regfile[28][28]
XU1119 MX4X1 $PINS Y=n3836 S1=n4265 S0=N25 D=n4073 C=n4075 B=n4074 A=n4076
XU1120 MXI4X1 $PINS Y=n4076 S1=n4269 S0=n4289 D=regfile[19][29]
+ C=regfile[18][29] B=regfile[17][29] A=regfile[16][29]
XU1121 MXI4X1 $PINS Y=n4074 S1=n4274 S0=n4289 D=regfile[27][29]
+ C=regfile[26][29] B=regfile[25][29] A=regfile[24][29]
XU1122 MXI4X1 $PINS Y=n4073 S1=n4279 S0=n4289 D=regfile[31][29]
+ C=regfile[30][29] B=regfile[29][29] A=regfile[28][29]
XU1123 MX4X1 $PINS Y=n3838 S1=n4265 S0=N25 D=n4081 C=n4083 B=n4082 A=n4084
XU1124 MXI4X1 $PINS Y=n4084 S1=n4274 S0=n4289 D=regfile[19][30]
+ C=regfile[18][30] B=regfile[17][30] A=regfile[16][30]
XU1125 MXI4X1 $PINS Y=n4082 S1=n4279 S0=n4289 D=regfile[27][30]
+ C=regfile[26][30] B=regfile[25][30] A=regfile[24][30]
XU1126 MXI4X1 $PINS Y=n4081 S1=n4276 S0=n4289 D=regfile[31][30]
+ C=regfile[30][30] B=regfile[29][30] A=regfile[28][30]
XU1128 MXI4X1 $PINS Y=n4092 S1=n4271 S0=n4290 D=regfile[19][31]
+ C=regfile[18][31] B=regfile[17][31] A=regfile[16][31]
XU1129 MXI4X1 $PINS Y=n4090 S1=n4266 S0=n4290 D=regfile[27][31]
+ C=regfile[26][31] B=regfile[25][31] A=regfile[24][31]
XU1130 MXI4X1 $PINS Y=n4089 S1=n4266 S0=n4290 D=regfile[31][31]
+ C=regfile[30][31] B=regfile[29][31] A=regfile[28][31]
XU1131 MX4X1 $PINS Y=n161 S1=n3738 S0=n3734 D=n256 C=n258 B=n257 A=n259
XU1132 MXI4X1 $PINS Y=n259 S1=FE_OFN222_n3745 S0=n3766 D=regfile[19][2]
+ C=regfile[18][2] B=regfile[17][2] A=regfile[16][2]
XU1133 MXI4X1 $PINS Y=n257 S1=FE_OFN222_n3745 S0=n3766 D=regfile[27][2]
+ C=regfile[26][2] B=regfile[25][2] A=regfile[24][2]
XU1134 MXI4X1 $PINS Y=n256 S1=FE_OFN222_n3745 S0=n3766 D=regfile[31][2]
+ C=regfile[30][2] B=regfile[29][2] A=regfile[28][2]
XU1135 MX4X1 $PINS Y=n163 S1=n3738 S0=n3734 D=n264 C=n266 B=n265 A=n267
XU1136 MXI4X1 $PINS Y=n267 S1=n3751 S0=n3767 D=regfile[19][3] C=regfile[18][3]
+ B=regfile[17][3] A=regfile[16][3]
XU1137 MXI4X1 $PINS Y=n265 S1=n3741 S0=n3766 D=regfile[27][3] C=regfile[26][3]
+ B=regfile[25][3] A=regfile[24][3]
XU1138 MXI4X1 $PINS Y=n264 S1=n3746 S0=n3766 D=regfile[31][3] C=regfile[30][3]
+ B=regfile[29][3] A=regfile[28][3]
XU1139 MX4X1 $PINS Y=n165 S1=n3738 S0=n3734 D=n272 C=n274 B=n273 A=n275
XU1140 MXI4X1 $PINS Y=n275 S1=n3746 S0=n3767 D=regfile[19][4] C=regfile[18][4]
+ B=regfile[17][4] A=regfile[16][4]
XU1141 MXI4X1 $PINS Y=n273 S1=n3755 S0=n3767 D=regfile[27][4] C=regfile[26][4]
+ B=regfile[25][4] A=regfile[24][4]
XU1142 MXI4X1 $PINS Y=n272 S1=n3753 S0=n3767 D=regfile[31][4] C=regfile[30][4]
+ B=regfile[29][4] A=regfile[28][4]
XU1144 MXI4X1 $PINS Y=n283 S1=n3751 S0=n3767 D=regfile[19][5] C=regfile[18][5]
+ B=regfile[17][5] A=regfile[16][5]
XU1145 MXI4X1 $PINS Y=n281 S1=n3753 S0=n3767 D=regfile[27][5] C=regfile[26][5]
+ B=regfile[25][5] A=regfile[24][5]
XU1146 MXI4X1 $PINS Y=n280 S1=n3755 S0=n3767 D=regfile[31][5] C=regfile[30][5]
+ B=regfile[29][5] A=regfile[28][5]
XU1147 MX4X1 $PINS Y=n174 S1=n3738 S0=n3734 D=n288 C=n290 B=n289 A=n291
XU1148 MXI4X1 $PINS Y=n288 S1=n3755 S0=n3768 D=regfile[31][6] C=regfile[30][6]
+ B=regfile[29][6] A=regfile[28][6]
XU1149 MX4X1 $PINS Y=n188 S1=n3738 S0=n3734 D=n296 C=n298 B=n297 A=n299
XU1150 MXI4X1 $PINS Y=n297 S1=FE_OFN217_n3742 S0=n3768 D=regfile[27][7]
+ C=regfile[26][7] B=regfile[25][7] A=regfile[24][7]
XU1151 MXI4X1 $PINS Y=n296 S1=FE_OFN222_n3745 S0=n3768 D=regfile[31][7]
+ C=regfile[30][7] B=regfile[29][7] A=regfile[28][7]
XU1152 MX4X1 $PINS Y=n190 S1=n3739 S0=N20 D=n304 C=n306 B=n305 A=n307
XU1153 MXI4X1 $PINS Y=n307 S1=n3754 S0=n3769 D=regfile[19][8] C=regfile[18][8]
+ B=regfile[17][8] A=regfile[16][8]
XU1154 MXI4X1 $PINS Y=n305 S1=n3755 S0=n3769 D=regfile[27][8] C=regfile[26][8]
+ B=regfile[25][8] A=regfile[24][8]
XU1155 MXI4X1 $PINS Y=n304 S1=FE_OFN219_n3749 S0=n3772 D=regfile[31][8]
+ C=regfile[30][8] B=regfile[29][8] A=regfile[28][8]
XU1156 MX4X1 $PINS Y=n194 S1=n3739 S0=N20 D=n312 C=n314 B=n313 A=n315
XU1157 MXI4X1 $PINS Y=n315 S1=FE_OFN220_n3747 S0=n3769 D=regfile[19][9]
+ C=regfile[18][9] B=regfile[17][9] A=regfile[16][9]
XU1158 MXI4X1 $PINS Y=n313 S1=FE_OFN220_n3747 S0=n3769 D=regfile[27][9]
+ C=regfile[26][9] B=regfile[25][9] A=regfile[24][9]
XU1159 MXI4X1 $PINS Y=n312 S1=n3741 S0=n3769 D=regfile[31][9] C=regfile[30][9]
+ B=regfile[29][9] A=regfile[28][9]
XU1160 MX4X1 $PINS Y=n196 S1=n3739 S0=N20 D=n320 C=n322 B=n321 A=n323
XU1161 MXI4X1 $PINS Y=n323 S1=FE_OFN220_n3747 S0=n3770 D=regfile[19][10]
+ C=regfile[18][10] B=regfile[17][10] A=regfile[16][10]
XU1162 MXI4X1 $PINS Y=n321 S1=FE_OFN220_n3747 S0=n3770 D=regfile[27][10]
+ C=regfile[26][10] B=regfile[25][10] A=regfile[24][10]
XU1163 MXI4X1 $PINS Y=n320 S1=FE_OFN220_n3747 S0=n3770 D=regfile[31][10]
+ C=regfile[30][10] B=regfile[29][10] A=regfile[28][10]
XU1164 MXI4X1 $PINS Y=n331 S1=FE_OFN220_n3747 S0=n3770 D=regfile[19][11]
+ C=regfile[18][11] B=regfile[17][11] A=regfile[16][11]
XU1165 MXI4X1 $PINS Y=n329 S1=FE_OFN220_n3747 S0=n3770 D=regfile[27][11]
+ C=regfile[26][11] B=regfile[25][11] A=regfile[24][11]
XU1166 MXI4X1 $PINS Y=n328 S1=FE_OFN220_n3747 S0=n3770 D=regfile[31][11]
+ C=regfile[30][11] B=regfile[29][11] A=regfile[28][11]
XU1167 MX4X1 $PINS Y=n200 S1=n3739 S0=N20 D=n336 C=n338 B=n337 A=n339
XU1168 MXI4X1 $PINS Y=n339 S1=FE_OFN218_n3743 S0=n3771 D=regfile[19][12]
+ C=regfile[18][12] B=regfile[17][12] A=regfile[16][12]
XU1169 MXI4X1 $PINS Y=n337 S1=FE_OFN220_n3747 S0=n3771 D=regfile[27][12]
+ C=regfile[26][12] B=regfile[25][12] A=regfile[24][12]
XU1170 MXI4X1 $PINS Y=n336 S1=FE_OFN220_n3747 S0=n3771 D=regfile[31][12]
+ C=regfile[30][12] B=regfile[29][12] A=regfile[28][12]
XU1171 MX4X1 $PINS Y=n202 S1=n3739 S0=N20 D=n344 C=n346 B=n345 A=n347
XU1172 MXI4X1 $PINS Y=n347 S1=FE_OFN218_n3743 S0=n3771 D=regfile[19][13]
+ C=regfile[18][13] B=regfile[17][13] A=regfile[16][13]
XU1173 MXI4X1 $PINS Y=n345 S1=n3752 S0=n3771 D=regfile[27][13]
+ C=regfile[26][13] B=regfile[25][13] A=regfile[24][13]
XU1174 MXI4X1 $PINS Y=n344 S1=n3753 S0=n3771 D=regfile[31][13]
+ C=regfile[30][13] B=regfile[29][13] A=regfile[28][13]
XU1175 MX4X1 $PINS Y=n204 S1=N19 S0=n3735 D=n352 C=n354 B=n353 A=n355
XU1176 MXI4X1 $PINS Y=n355 S1=n3753 S0=n3772 D=regfile[19][14]
+ C=regfile[18][14] B=regfile[17][14] A=regfile[16][14]
XU1177 MXI4X1 $PINS Y=n353 S1=n3752 S0=n3772 D=regfile[27][14]
+ C=regfile[26][14] B=regfile[25][14] A=regfile[24][14]
XU1178 MXI4X1 $PINS Y=n352 S1=n3748 S0=n3771 D=regfile[31][14]
+ C=regfile[30][14] B=regfile[29][14] A=regfile[28][14]
XU1179 MX4X1 $PINS Y=n206 S1=n3738 S0=n3735 D=n360 C=n362 B=n361 A=n363
XU1180 MXI4X1 $PINS Y=n363 S1=n3755 S0=n3772 D=regfile[19][15]
+ C=regfile[18][15] B=regfile[17][15] A=regfile[16][15]
XU1181 MXI4X1 $PINS Y=n361 S1=n3754 S0=n3772 D=regfile[27][15]
+ C=regfile[26][15] B=regfile[25][15] A=regfile[24][15]
XU1182 MXI4X1 $PINS Y=n360 S1=n3751 S0=n3772 D=regfile[31][15]
+ C=regfile[30][15] B=regfile[29][15] A=regfile[28][15]
XU1183 MX4X1 $PINS Y=n208 S1=n3738 S0=n3735 D=n368 C=n370 B=n369 A=n371
XU1184 MXI4X1 $PINS Y=n371 S1=FE_OFN217_n3742 S0=n3758 D=regfile[19][16]
+ C=regfile[18][16] B=regfile[17][16] A=regfile[16][16]
XU1185 MXI4X1 $PINS Y=n369 S1=FE_OFN218_n3743 S0=n3758 D=regfile[27][16]
+ C=regfile[26][16] B=regfile[25][16] A=regfile[24][16]
XU1186 MXI4X1 $PINS Y=n368 S1=n3755 S0=n3758 D=regfile[31][16]
+ C=regfile[30][16] B=regfile[29][16] A=regfile[28][16]
XU1187 MX4X1 $PINS Y=n210 S1=n3739 S0=n3735 D=n376 C=n378 B=n377 A=n379
XU1188 MXI4X1 $PINS Y=n379 S1=n3753 S0=n3758 D=regfile[19][17]
+ C=regfile[18][17] B=regfile[17][17] A=regfile[16][17]
XU1189 MXI4X1 $PINS Y=n377 S1=n3751 S0=n3758 D=regfile[27][17]
+ C=regfile[26][17] B=regfile[25][17] A=regfile[24][17]
XU1190 MXI4X1 $PINS Y=n376 S1=n3748 S0=n3758 D=regfile[31][17]
+ C=regfile[30][17] B=regfile[29][17] A=regfile[28][17]
XU1191 MX4X1 $PINS Y=n212 S1=n3738 S0=n3735 D=n384 C=n386 B=n385 A=n387
XU1192 MXI4X1 $PINS Y=n387 S1=n3748 S0=n3759 D=regfile[19][18]
+ C=regfile[18][18] B=regfile[17][18] A=regfile[16][18]
XU1193 MXI4X1 $PINS Y=n385 S1=n3754 S0=n3759 D=regfile[27][18]
+ C=regfile[26][18] B=regfile[25][18] A=regfile[24][18]
XU1194 MXI4X1 $PINS Y=n384 S1=n3752 S0=n3758 D=regfile[31][18]
+ C=regfile[30][18] B=regfile[29][18] A=regfile[28][18]
XU1195 MX4X1 $PINS Y=n214 S1=N19 S0=n3735 D=n392 C=n394 B=n393 A=n395
XU1196 MXI4X1 $PINS Y=n395 S1=n3754 S0=n3759 D=regfile[19][19]
+ C=regfile[18][19] B=regfile[17][19] A=regfile[16][19]
XU1197 MXI4X1 $PINS Y=n393 S1=n3755 S0=n3759 D=regfile[27][19]
+ C=regfile[26][19] B=regfile[25][19] A=regfile[24][19]
XU1198 MXI4X1 $PINS Y=n392 S1=FE_OFN218_n3743 S0=n3759 D=regfile[31][19]
+ C=regfile[30][19] B=regfile[29][19] A=regfile[28][19]
XU1199 MX4X1 $PINS Y=n216 S1=n3740 S0=n3736 D=n400 C=n402 B=n401 A=n403
XU1200 MXI4X1 $PINS Y=n403 S1=n3753 S0=n3760 D=regfile[19][20]
+ C=regfile[18][20] B=regfile[17][20] A=regfile[16][20]
XU1201 MXI4X1 $PINS Y=n401 S1=FE_OFN218_n3743 S0=n3759 D=regfile[27][20]
+ C=regfile[26][20] B=regfile[25][20] A=regfile[24][20]
XU1202 MXI4X1 $PINS Y=n400 S1=FE_OFN217_n3742 S0=n3759 D=regfile[31][20]
+ C=regfile[30][20] B=regfile[29][20] A=regfile[28][20]
XU1203 MX4X1 $PINS Y=n218 S1=n3740 S0=n3736 D=n408 C=n410 B=n409 A=n411
XU1204 MXI4X1 $PINS Y=n411 S1=n3746 S0=n3760 D=regfile[19][21]
+ C=regfile[18][21] B=regfile[17][21] A=regfile[16][21]
XU1205 MXI4X1 $PINS Y=n409 S1=FE_OFN218_n3743 S0=n3760 D=regfile[27][21]
+ C=regfile[26][21] B=regfile[25][21] A=regfile[24][21]
XU1206 MXI4X1 $PINS Y=n408 S1=n3748 S0=n3760 D=regfile[31][21]
+ C=regfile[30][21] B=regfile[29][21] A=regfile[28][21]
XU1207 MX4X1 $PINS Y=n220 S1=N19 S0=n3736 D=n416 C=n418 B=n417 A=n419
XU1208 MXI4X1 $PINS Y=n419 S1=FE_OFN217_n3742 S0=n3761 D=regfile[19][22]
+ C=regfile[18][22] B=regfile[17][22] A=regfile[16][22]
XU1209 MXI4X1 $PINS Y=n417 S1=n3751 S0=n3760 D=regfile[27][22]
+ C=regfile[26][22] B=regfile[25][22] A=regfile[24][22]
XU1210 MXI4X1 $PINS Y=n416 S1=FE_OFN218_n3743 S0=n3760 D=regfile[31][22]
+ C=regfile[30][22] B=regfile[29][22] A=regfile[28][22]
XU1211 MX4X1 $PINS Y=n222 S1=n3739 S0=n3736 D=n424 C=n426 B=n425 A=n427
XU1212 MXI4X1 $PINS Y=n427 S1=FE_OFN217_n3742 S0=n3761 D=regfile[19][23]
+ C=regfile[18][23] B=regfile[17][23] A=regfile[16][23]
XU1213 MXI4X1 $PINS Y=n425 S1=FE_OFN218_n3743 S0=n3761 D=regfile[27][23]
+ C=regfile[26][23] B=regfile[25][23] A=regfile[24][23]
XU1214 MXI4X1 $PINS Y=n424 S1=n3748 S0=n3761 D=regfile[31][23]
+ C=regfile[30][23] B=regfile[29][23] A=regfile[28][23]
XU1215 MX4X1 $PINS Y=n225 S1=N19 S0=n3736 D=n432 C=n434 B=n433 A=n435
XU1216 MXI4X1 $PINS Y=n435 S1=n3751 S0=n3762 D=regfile[19][24]
+ C=regfile[18][24] B=regfile[17][24] A=regfile[16][24]
XU1217 MXI4X1 $PINS Y=n433 S1=n3753 S0=n3761 D=regfile[27][24]
+ C=regfile[26][24] B=regfile[25][24] A=regfile[24][24]
XU1218 MXI4X1 $PINS Y=n432 S1=FE_OFN217_n3742 S0=n3761 D=regfile[31][24]
+ C=regfile[30][24] B=regfile[29][24] A=regfile[28][24]
XU1219 MX4X1 $PINS Y=n227 S1=N19 S0=n3736 D=n440 C=n442 B=n441 A=n443
XU1220 MXI4X1 $PINS Y=n443 S1=n3755 S0=n3762 D=regfile[19][25]
+ C=regfile[18][25] B=regfile[17][25] A=regfile[16][25]
XU1221 MXI4X1 $PINS Y=n441 S1=FE_OFN220_n3747 S0=n3762 D=regfile[27][25]
+ C=regfile[26][25] B=regfile[25][25] A=regfile[24][25]
XU1222 MXI4X1 $PINS Y=n440 S1=FE_OFN220_n3747 S0=n3762 D=regfile[31][25]
+ C=regfile[30][25] B=regfile[29][25] A=regfile[28][25]
XU1223 MX4X1 $PINS Y=n229 S1=n3740 S0=n3737 D=n448 C=n450 B=n449 A=n451
XU1224 MXI4X1 $PINS Y=n451 S1=n3746 S0=n3762 D=regfile[19][26]
+ C=regfile[18][26] B=regfile[17][26] A=regfile[16][26]
XU1225 MXI4X1 $PINS Y=n449 S1=FE_OFN217_n3742 S0=n3762 D=regfile[27][26]
+ C=regfile[26][26] B=regfile[25][26] A=regfile[24][26]
XU1226 MXI4X1 $PINS Y=n448 S1=FE_OFN218_n3743 S0=n3762 D=regfile[31][26]
+ C=regfile[30][26] B=regfile[29][26] A=regfile[28][26]
XU1227 MX4X1 $PINS Y=n231 S1=n3740 S0=n3737 D=n456 C=n458 B=n457 A=n459
XU1228 MXI4X1 $PINS Y=n459 S1=n3748 S0=n3763 D=regfile[19][27]
+ C=regfile[18][27] B=regfile[17][27] A=regfile[16][27]
XU1229 MXI4X1 $PINS Y=n457 S1=n3755 S0=n3763 D=regfile[27][27]
+ C=regfile[26][27] B=regfile[25][27] A=regfile[24][27]
XU1230 MXI4X1 $PINS Y=n456 S1=n3748 S0=n3763 D=regfile[31][27]
+ C=regfile[30][27] B=regfile[29][27] A=regfile[28][27]
XU1231 MX4X1 $PINS Y=n233 S1=n3740 S0=n3737 D=n464 C=n466 B=n465 A=n467
XU1232 MXI4X1 $PINS Y=n467 S1=FE_OFN221_n3744 S0=n3763 D=regfile[19][28]
+ C=regfile[18][28] B=regfile[17][28] A=regfile[16][28]
XU1233 MXI4X1 $PINS Y=n465 S1=FE_OFN217_n3742 S0=n3763 D=regfile[27][28]
+ C=regfile[26][28] B=regfile[25][28] A=regfile[24][28]
XU1234 MXI4X1 $PINS Y=n464 S1=n3751 S0=n3763 D=regfile[31][28]
+ C=regfile[30][28] B=regfile[29][28] A=regfile[28][28]
XU1235 MX4X1 $PINS Y=n235 S1=n3740 S0=n3737 D=n472 C=n474 B=n473 A=n475
XU1236 MXI4X1 $PINS Y=n475 S1=FE_OFN221_n3744 S0=n3764 D=regfile[19][29]
+ C=regfile[18][29] B=regfile[17][29] A=regfile[16][29]
XU1237 MXI4X1 $PINS Y=n473 S1=FE_OFN221_n3744 S0=n3764 D=regfile[27][29]
+ C=regfile[26][29] B=regfile[25][29] A=regfile[24][29]
XU1238 MXI4X1 $PINS Y=n472 S1=FE_OFN221_n3744 S0=n3764 D=regfile[31][29]
+ C=regfile[30][29] B=regfile[29][29] A=regfile[28][29]
XU1239 MX4X1 $PINS Y=n237 S1=n3740 S0=n3737 D=n480 C=n482 B=n481 A=n483
XU1240 MXI4X1 $PINS Y=n483 S1=FE_OFN221_n3744 S0=n3764 D=regfile[19][30]
+ C=regfile[18][30] B=regfile[17][30] A=regfile[16][30]
XU1241 MXI4X1 $PINS Y=n481 S1=FE_OFN221_n3744 S0=n3764 D=regfile[27][30]
+ C=regfile[26][30] B=regfile[25][30] A=regfile[24][30]
XU1242 MXI4X1 $PINS Y=n480 S1=FE_OFN221_n3744 S0=n3764 D=regfile[31][30]
+ C=regfile[30][30] B=regfile[29][30] A=regfile[28][30]
XU1243 MX4X1 $PINS Y=n239 S1=n3740 S0=n3737 D=n488 C=n490 B=n489 A=n491
XU1244 MXI4X1 $PINS Y=n491 S1=FE_OFN221_n3744 S0=n3765 D=regfile[19][31]
+ C=regfile[18][31] B=regfile[17][31] A=regfile[16][31]
XU1245 MXI4X1 $PINS Y=n489 S1=FE_OFN221_n3744 S0=n3765 D=regfile[27][31]
+ C=regfile[26][31] B=regfile[25][31] A=regfile[24][31]
XU1246 MXI4X1 $PINS Y=n488 S1=FE_OFN221_n3744 S0=n3765 D=regfile[31][31]
+ C=regfile[30][31] B=regfile[29][31] A=regfile[28][31]
XU1247 MX4X1 $PINS Y=n3778 S1=n4265 S0=N25 D=n3841 C=n3843 B=n3842 A=n3844
XU1248 MXI4X1 $PINS Y=n3844 S1=n4277 S0=n4290 D=regfile[19][0] C=regfile[18][0]
+ B=regfile[17][0] A=regfile[16][0]
XU1249 MXI4X1 $PINS Y=n3842 S1=n4270 S0=n4290 D=regfile[27][0] C=regfile[26][0]
+ B=regfile[25][0] A=regfile[24][0]
XU1250 MXI4X1 $PINS Y=n3841 S1=n4277 S0=n4290 D=regfile[31][0] C=regfile[30][0]
+ B=regfile[29][0] A=regfile[28][0]
XU1251 MX4X1 $PINS Y=n3780 S1=n4262 S0=n4426 D=n3849 C=n3851 B=n3850 A=n3852
XU1252 MXI4X1 $PINS Y=n3852 S1=n4274 S0=n4291 D=regfile[19][1] C=regfile[18][1]
+ B=regfile[17][1] A=regfile[16][1]
XU1253 MXI4X1 $PINS Y=n3850 S1=n4279 S0=n4290 D=regfile[27][1] C=regfile[26][1]
+ B=regfile[25][1] A=regfile[24][1]
XU1254 MXI4X1 $PINS Y=n3849 S1=n4275 S0=n4290 D=regfile[31][1] C=regfile[30][1]
+ B=regfile[29][1] A=regfile[28][1]
XU1255 MX4X1 $PINS Y=n157 S1=n3739 S0=n3733 D=n240 C=n242 B=n241 A=n243
XU1256 MXI4X1 $PINS Y=n243 S1=FE_OFN222_n3745 S0=n3765 D=regfile[19][0]
+ C=regfile[18][0] B=regfile[17][0] A=regfile[16][0]
XU1257 MXI4X1 $PINS Y=n241 S1=FE_OFN222_n3745 S0=n3765 D=regfile[27][0]
+ C=regfile[26][0] B=regfile[25][0] A=regfile[24][0]
XU1258 MXI4X1 $PINS Y=n240 S1=FE_OFN222_n3745 S0=n3765 D=regfile[31][0]
+ C=regfile[30][0] B=regfile[29][0] A=regfile[28][0]
XU1259 MX4X1 $PINS Y=n159 S1=n3740 S0=n3734 D=n248 C=n250 B=n249 A=n251
XU1260 MXI4X1 $PINS Y=n251 S1=FE_OFN222_n3745 S0=n3766 D=regfile[19][1]
+ C=regfile[18][1] B=regfile[17][1] A=regfile[16][1]
XU1261 MXI4X1 $PINS Y=n249 S1=FE_OFN222_n3745 S0=n3765 D=regfile[27][1]
+ C=regfile[26][1] B=regfile[25][1] A=regfile[24][1]
XU1262 MXI4X1 $PINS Y=n248 S1=FE_OFN222_n3745 S0=n3765 D=regfile[31][1]
+ C=regfile[30][1] B=regfile[29][1] A=regfile[28][1]
XU1264 MX4X1 $PINS Y=n3813 S1=n4263 S0=N25 D=n3989 C=n3991 B=n3990 A=n3992
XU1265 MX4X1 $PINS Y=n3823 S1=n4264 S0=n4261 D=n4029 C=n4031 B=n4030 A=n4032
XU1267 MX4X1 $PINS Y=n3779 S1=N24 S0=n4258 D=n3853 C=n3855 B=n3854 A=n3856
XU1268 MX4X1 $PINS Y=n3781 S1=n4262 S0=n4259 D=n3861 C=n3863 B=n3862 A=n3864
XU1269 MX4X1 $PINS Y=n3783 S1=n4262 S0=n4259 D=n3869 C=n3871 B=n3870 A=n3872
XU1270 MX4X1 $PINS Y=n3787 S1=n4262 S0=n4259 D=n3885 C=n3887 B=n3886 A=n3888
XU1271 MX4X1 $PINS Y=n3793 S1=N24 S0=N25 D=n3909 C=n3911 B=n3910 A=n3912
XU1272 MX4X1 $PINS Y=n3795 S1=N24 S0=N25 D=n3917 C=n3919 B=n3918 A=n3920
XU1275 MX4X1 $PINS Y=n3799 S1=N24 S0=n4258 D=n3933 C=n3935 B=n3934 A=n3936
XU1278 MX4X1 $PINS Y=n3803 S1=N24 S0=n4258 D=n3949 C=n3951 B=n3950 A=n3952
XU1280 MX4X1 $PINS Y=n3805 S1=n4263 S0=N25 D=n3957 C=n3959 B=n3958 A=n3960
XU1282 MX4X1 $PINS Y=n3807 S1=n4263 S0=N25 D=n3965 C=n3967 B=n3966 A=n3968
XU1288 MX4X1 $PINS Y=n3825 S1=n4264 S0=n4261 D=n4037 C=n4039 B=n4038 A=n4040
XU1289 MX4X1 $PINS Y=n3827 S1=n4264 S0=n4261 D=n4045 C=n4047 B=n4046 A=n4048
XU1291 MX4X1 $PINS Y=n3829 S1=n4265 S0=N25 D=n4053 C=n4055 B=n4054 A=n4056
XU1293 MX4X1 $PINS Y=n3831 S1=n4265 S0=N25 D=n4061 C=n4063 B=n4062 A=n4064
XU1295 MX4X1 $PINS Y=n3833 S1=n4265 S0=N25 D=n4069 C=n4071 B=n4070 A=n4072
XU1296 MX4X1 $PINS Y=n3835 S1=n4265 S0=N25 D=n4077 C=n4079 B=n4078 A=n4080
XU1298 MX4X1 $PINS Y=n3837 S1=n4265 S0=N25 D=n4085 C=n4087 B=n4086 A=n4088
XU1301 NOR2BX1 $PINS Y=n3727 B=n92 AN=n3750
XU1302 NOR2BX1 $PINS Y=n3722 B=regfile[3][1] AN=n3750
XU1303 NOR2BX1 $PINS Y=n3717 B=regfile[3][2] AN=n3750
XU1304 NOR2BX1 $PINS Y=n3712 B=regfile[3][3] AN=n3750
XU1305 NOR2BX1 $PINS Y=n3707 B=n90 AN=n3750
XU1306 NOR2BX1 $PINS Y=n3702 B=regfile[3][5] AN=FE_OFN219_n3749
XU1307 NOR2BX1 $PINS Y=n3697 B=regfile[3][6] AN=n3750
XU1308 NOR2BX1 $PINS Y=n3692 B=n89 AN=FE_OFN219_n3749
XU1309 NOR2BX1 $PINS Y=n1777 B=regfile[3][8] AN=FE_OFN219_n3749
XU1310 NOR2BX1 $PINS Y=n1741 B=regfile[3][9] AN=FE_OFN219_n3749
XU1311 NOR2BX1 $PINS Y=n1731 B=n88 AN=FE_OFN219_n3749
XU1312 NOR2BX1 $PINS Y=n1721 B=regfile[3][11] AN=FE_OFN219_n3749
XU1313 NOR2BX1 $PINS Y=n1711 B=regfile[3][12] AN=n3750
XU1314 NOR2BX1 $PINS Y=n1701 B=regfile[3][13] AN=n3749
XU1315 NOR2BX1 $PINS Y=n1691 B=regfile[3][14] AN=n3749
XU1316 NOR2BX1 $PINS Y=n1681 B=regfile[3][15] AN=n3749
XU1317 NOR2BX1 $PINS Y=n628 B=regfile[3][16] AN=n3749
XU1318 NOR2BX1 $PINS Y=n566 B=regfile[3][17] AN=n3749
XU1319 NOR2BX1 $PINS Y=n561 B=n91 AN=n3749
XU1320 NOR2BX1 $PINS Y=n556 B=n94 AN=n3749
XU1321 NOR2BX1 $PINS Y=n551 B=n85 AN=n3749
XU1322 NOR2BX1 $PINS Y=n546 B=regfile[3][21] AN=n3749
XU1323 NOR2BX1 $PINS Y=n541 B=regfile[3][22] AN=n3749
XU1324 NOR2BX1 $PINS Y=n536 B=n87 AN=n3749
XU1325 NOR2BX1 $PINS Y=n531 B=regfile[3][24] AN=FE_OFN219_n3749
XU1326 NOR2BX1 $PINS Y=n526 B=regfile[3][25] AN=n3750
XU1327 NOR2BX1 $PINS Y=n521 B=regfile[3][26] AN=n3750
XU1328 NOR2BX1 $PINS Y=n516 B=regfile[3][27] AN=n3750
XU1329 NOR2BX1 $PINS Y=n511 B=regfile[3][28] AN=n3750
XU1330 NOR2BX1 $PINS Y=n506 B=regfile[3][29] AN=n3750
XU1331 NOR2BX1 $PINS Y=n501 B=regfile[3][30] AN=n3750
XU1332 NOR2BX1 $PINS Y=n496 B=regfile[3][31] AN=n3750
XU1333 NOR2X1 $PINS Y=n3709 B=regfile[1][4] A=n3750
XU1334 NOR2X1 $PINS Y=n3699 B=regfile[1][6] A=n3750
XU1335 NOR2X1 $PINS Y=n3729 B=n3741 A=regfile[1][0]
XU1336 NOR2X1 $PINS Y=n3724 B=regfile[1][1] A=n3742
XU1338 NOR2X1 $PINS Y=n3714 B=regfile[1][3] A=n3748
XU1339 NOR2X1 $PINS Y=n3704 B=n3755 A=regfile[1][5]
XU1340 NOR2X1 $PINS Y=n3694 B=regfile[1][7] A=n3746
XU1342 NOR2X1 $PINS Y=n1749 B=regfile[1][9] A=n3742
XU1343 NOR2X1 $PINS Y=n1735 B=regfile[1][10] A=n3751
XU1344 NOR2X1 $PINS Y=n1725 B=regfile[1][11] A=n3741
XU1345 NOR2X1 $PINS Y=n1715 B=regfile[1][12] A=n3748
XU1346 NOR2X1 $PINS Y=n1705 B=regfile[1][13] A=n3755
XU1347 NOR2X1 $PINS Y=n1695 B=regfile[1][14] A=n3751
XU1348 NOR2X1 $PINS Y=n1685 B=regfile[1][15] A=FE_OFN218_n3743
XU1350 NOR2X1 $PINS Y=n568 B=regfile[1][17] A=n3748
XU1351 NOR2X1 $PINS Y=n563 B=regfile[1][18] A=FE_OFN217_n3742
XU1352 NOR2X1 $PINS Y=n558 B=regfile[1][19] A=n3746
XU1353 NOR2X1 $PINS Y=n553 B=regfile[1][20] A=n3748
XU1354 NOR2X1 $PINS Y=n548 B=regfile[1][21] A=n3754
XU1355 NOR2X1 $PINS Y=n543 B=regfile[1][22] A=n3751
XU1356 NOR2X1 $PINS Y=n538 B=regfile[1][23] A=n3755
XU1357 NOR2X1 $PINS Y=n533 B=n3742 A=regfile[1][24]
XU1358 NOR2X1 $PINS Y=n528 B=regfile[1][25] A=FE_OFN218_n3743
XU1359 NOR2X1 $PINS Y=n523 B=n3746 A=regfile[1][26]
XU1360 NOR2X1 $PINS Y=n518 B=regfile[1][27] A=n3741
XU1361 NOR2X1 $PINS Y=n513 B=regfile[1][28] A=n3742
XU1362 NOR2X1 $PINS Y=n508 B=regfile[1][29] A=n3752
XU1364 NOR2X1 $PINS Y=n498 B=regfile[1][31] A=n3754
XU1365 NOR2X1 $PINS Y=n4251 B=n4248 A=n4249
XU1366 NOR2X1 $PINS Y=n4248 B=n4299 A=n4276
XU1367 NOR2X1 $PINS Y=n3726 B=n3723 A=n3724
XU1368 NOR2X1 $PINS Y=n3723 B=n3773 A=n3754
XU1371 NOR2X1 $PINS Y=n4243 B=n4299 A=n4270
XU1372 NAND2X1 $PINS Y=n3872 B=n4240 A=n4241
XU1373 NOR2X1 $PINS Y=n4241 B=n4238 A=n4239
XU1374 MXI2X1 $PINS Y=n4240 S0=n4300 B=n4237 A=n1577
XU1375 NOR2X1 $PINS Y=n4238 B=n4299 A=n4278
XU1376 NAND2X1 $PINS Y=n3880 B=n4235 A=n4236
XU1377 NOR2X1 $PINS Y=n4236 B=n4233 A=n4234
XU1379 NOR2X1 $PINS Y=n4233 B=n4299 A=n4277
XU1380 NAND2X1 $PINS Y=n3888 B=n4230 A=n4231
XU1381 NOR2X1 $PINS Y=n4231 B=n4228 A=n4229
XU1383 NOR2X1 $PINS Y=n4228 B=n4299 A=n4280
XU1384 NAND2X1 $PINS Y=n3896 B=n4226 A=n4225
XU1385 NOR2X1 $PINS Y=n4226 B=n4223 A=n4224
XU1387 NOR2X1 $PINS Y=n4223 B=n4299 A=n4268
XU1388 NAND2X1 $PINS Y=n3904 B=n4220 A=n4221
XU1389 NOR2X1 $PINS Y=n4221 B=n4233 A=n4219
XU1392 NAND2X1 $PINS Y=n3912 B=n4215 A=n4216
XU1393 NOR2X1 $PINS Y=n4216 B=n4248 A=n4214
XU1396 NAND2X1 $PINS Y=n3920 B=n4210 A=n4211
XU1397 NOR2X1 $PINS Y=n4211 B=n4208 A=n4209
XU1399 NOR2X1 $PINS Y=n4208 B=n4299 A=n4274
XU1400 NAND2X1 $PINS Y=n3928 B=n4205 A=n4206
XU1401 MXI2X1 $PINS Y=n4205 S0=n4300 B=n4202 A=n1570
XU1402 NOR2X1 $PINS Y=n4203 B=n4300 A=n4270
XU1403 NAND2X1 $PINS Y=n3936 B=n4200 A=n4201
XU1404 NOR2X1 $PINS Y=n4201 B=n4248 A=n4199
XU1407 NAND2X1 $PINS Y=n3944 B=n4195 A=n4196
XU1408 NOR2X1 $PINS Y=n4196 B=n4233 A=n4194
XU1409 MXI2X1 $PINS Y=n4195 S0=n4300 B=n4192 A=n1568
XU1411 NAND2X1 $PINS Y=n3952 B=n4190 A=n4191
XU1412 NOR2X1 $PINS Y=n4191 B=n4188 A=n4189
XU1414 NOR2X1 $PINS Y=n4188 B=n4299 A=n4279
XU1415 NAND2X1 $PINS Y=n3960 B=n4185 A=n4186
XU1416 NOR2X1 $PINS Y=n4186 B=n4223 A=n4184
XU1417 MXI2X1 $PINS Y=n4185 S0=n4300 B=n4182 A=n1566
XU1419 NAND2X1 $PINS Y=n3968 B=n4180 A=n4181
XU1420 NOR2X1 $PINS Y=n4181 B=n4178 A=n4179
XU1421 MXI2X1 $PINS Y=n4180 S0=n4299 B=n4177 A=n1565
XU1422 NOR2X1 $PINS Y=n4178 B=n4300 A=n4268
XU1423 NAND2X1 $PINS Y=n3976 B=n4175 A=n4176
XU1424 NOR2X1 $PINS Y=n4176 B=n4173 A=n4174
XU1426 NOR2X1 $PINS Y=n4173 B=n4300 A=n4275
XU1427 NAND2X1 $PINS Y=n3984 B=n4170 A=n4171
XU1428 NOR2X1 $PINS Y=n4171 B=n4168 A=n4169
XU1429 MXI2X1 $PINS Y=n4170 S0=n4299 B=n4167 A=n1563
XU1430 NOR2X1 $PINS Y=n4168 B=n4300 A=n4277
XU1431 NAND2X1 $PINS Y=n3992 B=n4165 A=n4166
XU1432 NOR2X1 $PINS Y=n4166 B=n4163 A=n4164
XU1434 NOR2X1 $PINS Y=n4163 B=n4300 A=n4276
XU1435 NAND2X1 $PINS Y=n4000 B=n4160 A=n4161
XU1436 NOR2X1 $PINS Y=n4161 B=n4158 A=n4159
XU1438 NOR2X1 $PINS Y=n4158 B=n4300 A=n4279
XU1439 NAND2X1 $PINS Y=n4008 B=n4155 A=n4156
XU1440 NOR2X1 $PINS Y=n4156 B=n4153 A=n4154
XU1441 MXI2X1 $PINS Y=n4155 S0=n4299 B=n4152 A=n1560
XU1442 NOR2X1 $PINS Y=n4153 B=n4300 A=n4278
XU1443 NAND2X1 $PINS Y=n4016 B=n4150 A=n4151
XU1444 NOR2X1 $PINS Y=n4151 B=n4148 A=n4149
XU1445 MXI2X1 $PINS Y=n4150 S0=n4299 B=n4147 A=n1559
XU1446 NOR2X1 $PINS Y=n4148 B=n4300 A=n4274
XU1447 NAND2X1 $PINS Y=n4024 B=n4145 A=n4146
XU1448 NOR2X1 $PINS Y=n4146 B=n4148 A=n4144
XU1449 MXI2X1 $PINS Y=n4145 S0=n4299 B=n4142 A=n1558
XU1451 NAND2X1 $PINS Y=n4032 B=n4140 A=n4141
XU1452 NOR2X1 $PINS Y=n4141 B=n4158 A=n4139
XU1453 MXI2X1 $PINS Y=n4140 S0=n4299 B=n4137 A=n1557
XU1455 NAND2X1 $PINS Y=n4040 B=n4135 A=n4136
XU1456 NOR2X1 $PINS Y=n4136 B=n4153 A=n4134
XU1459 NAND2X1 $PINS Y=n4056 B=n4125 A=n4126
XU1460 NOR2X1 $PINS Y=n4126 B=n4238 A=n4124
XU1461 MXI2X1 $PINS Y=n4125 S0=n4299 B=n4122 A=n1554
XU1463 NAND2X1 $PINS Y=n4080 B=n4111 A=n4110
XU1464 NOR2X1 $PINS Y=n4111 B=n4238 A=n4109
XU1467 NAND2X1 $PINS Y=n4096 B=n4100 A=n4101
XU1468 NOR2X1 $PINS Y=n4101 B=n4243 A=n4099
XU1469 MXI2X1 $PINS Y=n4100 S0=n4299 B=n4097 A=n1549
XU1471 NAND2X1 $PINS Y=n263 B=n3720 A=n3721
XU1472 NOR2X1 $PINS Y=n3721 B=n3718 A=n3719
XU1474 NOR2X1 $PINS Y=n3718 B=n3773 A=n3746
XU1475 NAND2X1 $PINS Y=n271 B=n3715 A=n3716
XU1476 NOR2X1 $PINS Y=n3716 B=n3718 A=n3714
XU1477 MXI2X1 $PINS Y=n3715 S0=n3773 B=n3712 A=n1577
XU1479 NAND2X1 $PINS Y=n279 B=n3710 A=n3711
XU1480 NOR2X1 $PINS Y=n3711 B=n3708 A=n3709
XU1481 MXI2X1 $PINS Y=n3710 S0=n3773 B=n3707 A=n1576
XU1482 NOR2X1 $PINS Y=n3708 B=n3773 A=n3741
XU1483 NAND2X1 $PINS Y=n287 B=n3705 A=n3706
XU1484 NOR2X1 $PINS Y=n3706 B=n3703 A=n3704
XU1485 NOR2X1 $PINS Y=n3703 B=n3773 A=n3750
XU1486 NAND2X1 $PINS Y=n295 B=n3700 A=n3701
XU1487 NOR2X1 $PINS Y=n3701 B=n3698 A=n3699
XU1489 NOR2X1 $PINS Y=n3698 B=n3773 A=n3755
XU1490 NAND2X1 $PINS Y=n303 B=n3695 A=n3696
XU1491 NOR2X1 $PINS Y=n3696 B=n3693 A=n3694
XU1492 MXI2X1 $PINS Y=n3695 S0=n3773 B=n3692 A=n1573
XU1493 NOR2X1 $PINS Y=n3693 B=n3773 A=n3748
XU1494 NAND2X1 $PINS Y=n311 B=n1787 A=n3691
XU1495 NOR2X1 $PINS Y=n3691 B=n1779 A=n1781
XU1497 NOR2X1 $PINS Y=n1779 B=n3775 A=n3752
XU1498 NAND2X1 $PINS Y=n319 B=n1755 A=n1761
XU1499 NOR2X1 $PINS Y=n1761 B=n3723 A=n1749
XU1502 NAND2X1 $PINS Y=n327 B=n1737 A=n1739
XU1503 NOR2X1 $PINS Y=n1739 B=n1733 A=n1735
XU1504 MXI2X1 $PINS Y=n1737 S0=n3773 B=n1731 A=n1570
XU1505 NOR2X1 $PINS Y=n1733 B=n3775 A=n3753
XU1506 NAND2X1 $PINS Y=n335 B=n1727 A=n1729
XU1507 NOR2X1 $PINS Y=n1729 B=n1723 A=n1725
XU1508 MXI2X1 $PINS Y=n1727 S0=n3773 B=n1721 A=n1569
XU1509 NOR2X1 $PINS Y=n1723 B=n3773 A=n3753
XU1510 NAND2X1 $PINS Y=n343 B=n1717 A=n1719
XU1511 NOR2X1 $PINS Y=n1719 B=n1713 A=n1715
XU1512 MXI2X1 $PINS Y=n1717 S0=n3773 B=n1711 A=n1568
XU1513 NOR2X1 $PINS Y=n1713 B=n3775 A=n3746
XU1514 NAND2X1 $PINS Y=n351 B=n1707 A=n1709
XU1515 NOR2X1 $PINS Y=n1709 B=n3693 A=n1705
XU1518 NAND2X1 $PINS Y=n359 B=n1697 A=n1699
XU1519 NOR2X1 $PINS Y=n1699 B=n1693 A=n1695
XU1520 MXI2X1 $PINS Y=n1697 S0=n3773 B=n1691 A=n1566
XU1521 NOR2X1 $PINS Y=n1693 B=n3773 A=n3752
XU1522 NAND2X1 $PINS Y=n367 B=n1687 A=n1689
XU1523 NOR2X1 $PINS Y=n1689 B=n3693 A=n1685
XU1524 MXI2X1 $PINS Y=n1687 S0=n3774 B=n1681 A=n1565
XU1526 NAND2X1 $PINS Y=n375 B=n1677 A=n1679
XU1527 NOR2X1 $PINS Y=n1679 B=n1733 A=n630
XU1530 NAND2X1 $PINS Y=n383 B=n623 A=n627
XU1531 NOR2X1 $PINS Y=n627 B=n567 A=n568
XU1532 MXI2X1 $PINS Y=n623 S0=n3774 B=n566 A=n1563
XU1533 NOR2X1 $PINS Y=n567 B=n3775 A=FE_OFN218_n3743
XU1534 NAND2X1 $PINS Y=n391 B=n564 A=n565
XU1535 NOR2X1 $PINS Y=n565 B=n1693 A=n563
XU1536 MXI2X1 $PINS Y=n564 S0=n3774 B=n561 A=n1562
XU1538 NAND2X1 $PINS Y=n399 B=n559 A=n560
XU1539 NOR2X1 $PINS Y=n560 B=n557 A=n558
XU1540 MXI2X1 $PINS Y=n559 S0=n3774 B=n556 A=n1561
XU1541 NOR2X1 $PINS Y=n557 B=n3775 A=n3748
XU1542 NAND2X1 $PINS Y=n407 B=n554 A=n555
XU1543 NOR2X1 $PINS Y=n555 B=n1713 A=n553
XU1544 MXI2X1 $PINS Y=n554 S0=n3774 B=n551 A=n1560
XU1546 NAND2X1 $PINS Y=n415 B=n549 A=n550
XU1547 NOR2X1 $PINS Y=n550 B=n547 A=n548
XU1548 MXI2X1 $PINS Y=n549 S0=n3774 B=n546 A=n1559
XU1549 NOR2X1 $PINS Y=n547 B=n3775 A=FE_OFN217_n3742
XU1550 NAND2X1 $PINS Y=n423 B=n544 A=n545
XU1551 NOR2X1 $PINS Y=n545 B=n1779 A=n543
XU1552 MXI2X1 $PINS Y=n544 S0=n3774 B=n541 A=n1558
XU1554 NAND2X1 $PINS Y=n431 B=n539 A=n540
XU1555 NOR2X1 $PINS Y=n540 B=n1733 A=n538
XU1556 MXI2X1 $PINS Y=n539 S0=n3774 B=n536 A=n1557
XU1558 NAND2X1 $PINS Y=n439 B=n534 A=n535
XU1559 NOR2X1 $PINS Y=n535 B=n532 A=n533
XU1561 NOR2X1 $PINS Y=n532 B=n3775 A=n3754
XU1562 NAND2X1 $PINS Y=n455 B=n524 A=n525
XU1563 NOR2X1 $PINS Y=n525 B=n523 A=n557
XU1566 NAND2X1 $PINS Y=n479 B=n509 A=n510
XU1567 NOR2X1 $PINS Y=n510 B=n3723 A=n508
XU1570 NAND2X1 $PINS Y=n495 B=n499 A=n500
XU1571 NOR2X1 $PINS Y=n500 B=n3718 A=n498
XU1572 MXI2X1 $PINS Y=n499 S0=n3774 B=n496 A=n1549
XU1574 NAND2X1 $PINS Y=n3848 B=n4255 A=n4256
XU1575 NOR2X1 $PINS Y=n4256 B=n4253 A=n4254
XU1577 NOR2X1 $PINS Y=n4253 B=n4299 A=n4269
XU1578 NAND2X1 $PINS Y=n4048 B=n4130 A=n4131
XU1579 NOR2X1 $PINS Y=n4131 B=n4128 A=n4129
XU1581 NOR2X1 $PINS Y=n4128 B=n4284 A=n4274
XU1582 NAND2X1 $PINS Y=n4064 B=n4120 A=n4121
XU1583 NOR2X1 $PINS Y=n4121 B=n4253 A=n4119
XU1584 MXI2X1 $PINS Y=n4120 S0=n4300 B=n4117 A=n1553
XU1586 NAND2X1 $PINS Y=n4072 B=n4115 A=n4116
XU1587 NOR2X1 $PINS Y=n4116 B=n4253 A=n4114
XU1588 MXI2X1 $PINS Y=n4115 S0=n4300 B=n4112 A=n1552
XU1590 NAND2X1 $PINS Y=n4088 B=n4105 A=n4106
XU1591 NOR2X1 $PINS Y=n4106 B=n4248 A=n4104
XU1592 MXI2X1 $PINS Y=n4105 S0=n4300 B=n4102 A=n1550
XU1594 NAND2X1 $PINS Y=n247 B=n3730 A=n3731
XU1595 NOR2X1 $PINS Y=n3731 B=n3703 A=n3729
XU1598 NAND2X1 $PINS Y=n447 B=n529 A=n530
XU1599 NOR2X1 $PINS Y=n530 B=n527 A=n528
XU1600 MXI2X1 $PINS Y=n529 S0=n3775 B=n526 A=n1555
XU1601 NOR2X1 $PINS Y=n527 B=n3775 A=n3755
XU1602 NAND2X1 $PINS Y=n463 B=n519 A=n520
XU1603 NOR2X1 $PINS Y=n520 B=n517 A=n518
XU1605 NOR2X1 $PINS Y=n517 B=n3774 A=n3742
XU1606 NAND2X1 $PINS Y=n471 B=n514 A=n515
XU1607 NOR2X1 $PINS Y=n515 B=n3708 A=n513
XU1608 MXI2X1 $PINS Y=n514 S0=n3775 B=n511 A=n1552
XU1610 NAND2X1 $PINS Y=n487 B=n504 A=n505
XU1611 NOR2X1 $PINS Y=n505 B=n3718 A=n503
XU1614 MXI4X1 $PINS Y=n3843 S1=n4270 S0=n4290 D=regfile[23][0] C=regfile[22][0]
+ B=regfile[21][0] A=regfile[20][0]
XU1615 MXI4X1 $PINS Y=n3847 S1=n4269 S0=n4290 D=regfile[7][0] C=regfile[6][0]
+ B=regfile[5][0] A=regfile[4][0]
XU1616 MXI4X1 $PINS Y=n3851 S1=n4280 S0=n4291 D=regfile[23][1] C=regfile[22][1]
+ B=regfile[21][1] A=regfile[20][1]
XU1617 MXI4X1 $PINS Y=n3855 S1=n4269 S0=n4291 D=regfile[7][1] C=regfile[6][1]
+ B=regfile[5][1] A=regfile[4][1]
XU1618 MXI4X1 $PINS Y=n3859 S1=n4278 S0=n4291 D=regfile[23][2] C=regfile[22][2]
+ B=regfile[21][2] A=regfile[20][2]
XU1619 MXI4X1 $PINS Y=n3863 S1=n4269 S0=n4291 D=regfile[7][2] C=regfile[6][2]
+ B=regfile[5][2] A=regfile[4][2]
XU1620 MXI4X1 $PINS Y=n3867 S1=FE_OFN213_n4271 S0=n4291 D=regfile[23][3]
+ C=regfile[22][3] B=regfile[21][3] A=regfile[20][3]
XU1621 MXI4X1 $PINS Y=n3871 S1=FE_OFN213_n4271 S0=n4292 D=regfile[7][3]
+ C=regfile[6][3] B=regfile[5][3] A=regfile[4][3]
XU1622 MXI4X1 $PINS Y=n3875 S1=FE_OFN213_n4271 S0=n4292 D=regfile[23][4]
+ C=regfile[22][4] B=regfile[21][4] A=regfile[20][4]
XU1623 MXI4X1 $PINS Y=n3879 S1=FE_OFN213_n4271 S0=n4292 D=regfile[7][4]
+ C=regfile[6][4] B=regfile[5][4] A=regfile[4][4]
XU1624 MXI4X1 $PINS Y=n3883 S1=FE_OFN213_n4271 S0=n4292 D=regfile[23][5]
+ C=regfile[22][5] B=regfile[21][5] A=regfile[20][5]
XU1625 MXI4X1 $PINS Y=n3887 S1=FE_OFN213_n4271 S0=n4293 D=regfile[7][5]
+ C=regfile[6][5] B=regfile[5][5] A=regfile[4][5]
XU1626 MXI4X1 $PINS Y=n3891 S1=FE_OFN215_n4272 S0=n4293 D=regfile[23][6]
+ C=regfile[22][6] B=regfile[21][6] A=regfile[20][6]
XU1627 MXI4X1 $PINS Y=n3895 S1=FE_OFN215_n4272 S0=n4293 D=regfile[7][6]
+ C=regfile[6][6] B=regfile[5][6] A=regfile[4][6]
XU1628 MXI4X1 $PINS Y=n3899 S1=FE_OFN215_n4272 S0=n4293 D=regfile[23][7]
+ C=regfile[22][7] B=regfile[21][7] A=regfile[20][7]
XU1629 MXI4X1 $PINS Y=n3903 S1=FE_OFN215_n4272 S0=n4294 D=regfile[7][7]
+ C=regfile[6][7] B=regfile[5][7] A=regfile[4][7]
XU1630 MXI4X1 $PINS Y=n3907 S1=FE_OFN215_n4272 S0=n4294 D=regfile[23][8]
+ C=regfile[22][8] B=regfile[21][8] A=regfile[20][8]
XU1631 MXI4X1 $PINS Y=n3911 S1=FE_OFN215_n4272 S0=n4294 D=regfile[7][8]
+ C=regfile[6][8] B=regfile[5][8] A=regfile[4][8]
XU1632 MXI4X1 $PINS Y=n3915 S1=FE_OFN214_n4273 S0=n4294 D=regfile[23][9]
+ C=regfile[22][9] B=regfile[21][9] A=regfile[20][9]
XU1633 MXI4X1 $PINS Y=n3919 S1=FE_OFN214_n4273 S0=n4295 D=regfile[7][9]
+ C=regfile[6][9] B=regfile[5][9] A=regfile[4][9]
XU1634 MXI4X1 $PINS Y=n3923 S1=n4273 S0=n4295 D=regfile[23][10]
+ C=regfile[22][10] B=regfile[21][10] A=regfile[20][10]
XU1635 MXI4X1 $PINS Y=n3927 S1=FE_OFN214_n4273 S0=n4295 D=regfile[7][10]
+ C=regfile[6][10] B=regfile[5][10] A=regfile[4][10]
XU1636 MXI4X1 $PINS Y=n3931 S1=FE_OFN214_n4273 S0=n4295 D=regfile[23][11]
+ C=regfile[22][11] B=regfile[21][11] A=regfile[20][11]
XU1637 MXI4X1 $PINS Y=n3935 S1=FE_OFN214_n4273 S0=n4296 D=regfile[7][11]
+ C=regfile[6][11] B=regfile[5][11] A=regfile[4][11]
XU1638 MXI4X1 $PINS Y=n3939 S1=n4266 S0=n4296 D=regfile[23][12]
+ C=regfile[22][12] B=regfile[21][12] A=regfile[20][12]
XU1639 MXI4X1 $PINS Y=n3943 S1=n4272 S0=n4294 D=regfile[7][12] C=regfile[6][12]
+ B=regfile[5][12] A=regfile[4][12]
XU1640 MXI4X1 $PINS Y=n3947 S1=n4268 S0=n4296 D=regfile[23][13]
+ C=regfile[22][13] B=regfile[21][13] A=regfile[20][13]
XU1641 MXI4X1 $PINS Y=n3951 S1=n4270 S0=n4296 D=regfile[7][13] C=regfile[6][13]
+ B=regfile[5][13] A=regfile[4][13]
XU1642 MXI4X1 $PINS Y=n3955 S1=FE_OFN216_n4267 S0=n4297 D=regfile[23][14]
+ C=regfile[22][14] B=regfile[21][14] A=regfile[20][14]
XU1643 MXI4X1 $PINS Y=n3959 S1=n4277 S0=n4297 D=regfile[7][14] C=regfile[6][14]
+ B=regfile[5][14] A=regfile[4][14]
XU1644 MXI4X1 $PINS Y=n3963 S1=n4266 S0=n4297 D=regfile[23][15]
+ C=regfile[22][15] B=regfile[21][15] A=regfile[20][15]
XU1645 MXI4X1 $PINS Y=n3967 S1=n4272 S0=n4294 D=regfile[7][15] C=regfile[6][15]
+ B=regfile[5][15] A=regfile[4][15]
XU1646 MXI4X1 $PINS Y=n3971 S1=n4279 S0=n4283 D=regfile[23][16]
+ C=regfile[22][16] B=regfile[21][16] A=regfile[20][16]
XU1647 MXI4X1 $PINS Y=n3975 S1=n4275 S0=n4283 D=regfile[7][16] C=regfile[6][16]
+ B=regfile[5][16] A=regfile[4][16]
XU1648 MXI4X1 $PINS Y=n3979 S1=n4279 S0=n4283 D=regfile[23][17]
+ C=regfile[22][17] B=regfile[21][17] A=regfile[20][17]
XU1649 MXI4X1 $PINS Y=n3983 S1=FE_OFN216_n4267 S0=n4283 D=regfile[7][17]
+ C=regfile[6][17] B=regfile[5][17] A=regfile[4][17]
XU1650 MXI4X1 $PINS Y=n3987 S1=n4269 S0=n4284 D=regfile[23][18]
+ C=regfile[22][18] B=regfile[21][18] A=regfile[20][18]
XU1651 MXI4X1 $PINS Y=n3991 S1=n4277 S0=n4284 D=regfile[7][18] C=regfile[6][18]
+ B=regfile[5][18] A=regfile[4][18]
XU1652 MXI4X1 $PINS Y=n3995 S1=n4279 S0=n4284 D=regfile[23][19]
+ C=regfile[22][19] B=regfile[21][19] A=regfile[20][19]
XU1653 MXI4X1 $PINS Y=n3999 S1=n4274 S0=n4284 D=regfile[7][19] C=regfile[6][19]
+ B=regfile[5][19] A=regfile[4][19]
XU1654 MXI4X1 $PINS Y=n4003 S1=FE_OFN216_n4267 S0=n4285 D=regfile[23][20]
+ C=regfile[22][20] B=regfile[21][20] A=regfile[20][20]
XU1655 MXI4X1 $PINS Y=n4007 S1=FE_OFN216_n4267 S0=n4285 D=regfile[7][20]
+ C=regfile[6][20] B=regfile[5][20] A=regfile[4][20]
XU1656 MXI4X1 $PINS Y=n4011 S1=n4266 S0=n4285 D=regfile[23][21]
+ C=regfile[22][21] B=regfile[21][21] A=regfile[20][21]
XU1657 MXI4X1 $PINS Y=n4015 S1=n4266 S0=n4285 D=regfile[7][21] C=regfile[6][21]
+ B=regfile[5][21] A=regfile[4][21]
XU1658 MXI4X1 $PINS Y=n4019 S1=n4280 S0=n4285 D=regfile[23][22]
+ C=regfile[22][22] B=regfile[21][22] A=regfile[20][22]
XU1659 MXI4X1 $PINS Y=n4023 S1=FE_OFN216_n4267 S0=n4286 D=regfile[7][22]
+ C=regfile[6][22] B=regfile[5][22] A=regfile[4][22]
XU1660 MXI4X1 $PINS Y=n4027 S1=n4269 S0=n4286 D=regfile[23][23]
+ C=regfile[22][23] B=regfile[21][23] A=regfile[20][23]
XU1661 MXI4X1 $PINS Y=n4031 S1=n4274 S0=n4286 D=regfile[7][23] C=regfile[6][23]
+ B=regfile[5][23] A=regfile[4][23]
XU1662 MXI4X1 $PINS Y=n4035 S1=n4270 S0=n4286 D=regfile[23][24]
+ C=regfile[22][24] B=regfile[21][24] A=regfile[20][24]
XU1663 MXI4X1 $PINS Y=n4039 S1=n4276 S0=n4287 D=regfile[7][24] C=regfile[6][24]
+ B=regfile[5][24] A=regfile[4][24]
XU1664 MXI4X1 $PINS Y=n4043 S1=n4268 S0=n4287 D=regfile[23][25]
+ C=regfile[22][25] B=regfile[21][25] A=regfile[20][25]
XU1665 MXI4X1 $PINS Y=n4047 S1=n4277 S0=n4287 D=regfile[7][25] C=regfile[6][25]
+ B=regfile[5][25] A=regfile[4][25]
XU1666 MXI4X1 $PINS Y=n4051 S1=n4267 S0=n4287 D=regfile[23][26]
+ C=regfile[22][26] B=regfile[21][26] A=regfile[20][26]
XU1667 MXI4X1 $PINS Y=n4055 S1=n4278 S0=n4288 D=regfile[7][26] C=regfile[6][26]
+ B=regfile[5][26] A=regfile[4][26]
XU1668 MXI4X1 $PINS Y=n4059 S1=n4280 S0=n4288 D=regfile[23][27]
+ C=regfile[22][27] B=regfile[21][27] A=regfile[20][27]
XU1669 MXI4X1 $PINS Y=n4063 S1=n4274 S0=n4288 D=regfile[7][27] C=regfile[6][27]
+ B=regfile[5][27] A=regfile[4][27]
XU1670 MXI4X1 $PINS Y=n4067 S1=n4278 S0=n4288 D=regfile[23][28]
+ C=regfile[22][28] B=regfile[21][28] A=regfile[20][28]
XU1671 MXI4X1 $PINS Y=n4071 S1=n4271 S0=n4289 D=regfile[7][28] C=regfile[6][28]
+ B=regfile[5][28] A=regfile[4][28]
XU1672 MXI4X1 $PINS Y=n4075 S1=n4278 S0=n4289 D=regfile[23][29]
+ C=regfile[22][29] B=regfile[21][29] A=regfile[20][29]
XU1673 MXI4X1 $PINS Y=n4079 S1=n4278 S0=n4289 D=regfile[7][29] C=regfile[6][29]
+ B=regfile[5][29] A=regfile[4][29]
XU1674 MXI4X1 $PINS Y=n4083 S1=n4278 S0=n4289 D=regfile[23][30]
+ C=regfile[22][30] B=regfile[21][30] A=regfile[20][30]
XU1675 MXI4X1 $PINS Y=n4087 S1=n4271 S0=n4290 D=regfile[7][30] C=regfile[6][30]
+ B=regfile[5][30] A=regfile[4][30]
XU1676 MXI4X1 $PINS Y=n4091 S1=n4271 S0=n4290 D=regfile[23][31]
+ C=regfile[22][31] B=regfile[21][31] A=regfile[20][31]
XU1677 MXI4X1 $PINS Y=n4095 S1=n4266 S0=n4297 D=regfile[7][31] C=regfile[6][31]
+ B=regfile[5][31] A=regfile[4][31]
XU1678 MXI4X1 $PINS Y=n242 S1=FE_OFN222_n3745 S0=n3765 D=regfile[23][0]
+ C=regfile[22][0] B=regfile[21][0] A=regfile[20][0]
XU1679 MXI4X1 $PINS Y=n246 S1=n3745 S0=n3765 D=regfile[7][0] C=regfile[6][0]
+ B=regfile[5][0] A=regfile[4][0]
XU1680 MXI4X1 $PINS Y=n250 S1=FE_OFN222_n3745 S0=n3766 D=regfile[23][1]
+ C=regfile[22][1] B=regfile[21][1] A=regfile[20][1]
XU1681 MXI4X1 $PINS Y=n254 S1=n3745 S0=n3766 D=regfile[7][1] C=regfile[6][1]
+ B=regfile[5][1] A=regfile[4][1]
XU1682 MXI4X1 $PINS Y=n258 S1=FE_OFN222_n3745 S0=n3766 D=regfile[23][2]
+ C=regfile[22][2] B=regfile[21][2] A=regfile[20][2]
XU1683 MXI4X1 $PINS Y=n262 S1=n3745 S0=n3766 D=regfile[7][2] C=regfile[6][2]
+ B=regfile[5][2] A=regfile[4][2]
XU1684 MXI4X1 $PINS Y=n266 S1=FE_OFN217_n3742 S0=n3766 D=regfile[23][3]
+ C=regfile[22][3] B=regfile[21][3] A=regfile[20][3]
XU1717 MXI4X1 $PINS Y=n270 S1=n3741 S0=n3767 D=regfile[7][3] C=regfile[6][3]
+ B=regfile[5][3] A=regfile[4][3]
XU1718 MXI4X1 $PINS Y=n274 S1=n3746 S0=n3767 D=regfile[23][4] C=regfile[22][4]
+ B=regfile[21][4] A=regfile[20][4]
XU1719 MXI4X1 $PINS Y=n278 S1=n3755 S0=n3767 D=regfile[7][4] C=regfile[6][4]
+ B=regfile[5][4] A=regfile[4][4]
XU1720 MXI4X1 $PINS Y=n282 S1=n3754 S0=n3767 D=regfile[23][5] C=regfile[22][5]
+ B=regfile[21][5] A=regfile[20][5]
XU1721 MXI4X1 $PINS Y=n286 S1=n3753 S0=n3768 D=regfile[7][5] C=regfile[6][5]
+ B=regfile[5][5] A=regfile[4][5]
XU1722 MXI4X1 $PINS Y=n290 S1=FE_OFN222_n3745 S0=n3768 D=regfile[23][6]
+ C=regfile[22][6] B=regfile[21][6] A=regfile[20][6]
XU1723 MXI4X1 $PINS Y=n298 S1=FE_OFN217_n3742 S0=n3768 D=regfile[23][7]
+ C=regfile[22][7] B=regfile[21][7] A=regfile[20][7]
XU1724 MXI4X1 $PINS Y=n306 S1=n3751 S0=n3769 D=regfile[23][8] C=regfile[22][8]
+ B=regfile[21][8] A=regfile[20][8]
XU1725 MXI4X1 $PINS Y=n310 S1=n3745 S0=n3769 D=regfile[7][8] C=regfile[6][8]
+ B=regfile[5][8] A=regfile[4][8]
XU1726 MXI4X1 $PINS Y=n314 S1=FE_OFN220_n3747 S0=n3769 D=regfile[23][9]
+ C=regfile[22][9] B=regfile[21][9] A=regfile[20][9]
XU1727 MXI4X1 $PINS Y=n318 S1=n3747 S0=n3770 D=regfile[7][9] C=regfile[6][9]
+ B=regfile[5][9] A=regfile[4][9]
XU1728 MXI4X1 $PINS Y=n322 S1=FE_OFN220_n3747 S0=n3770 D=regfile[23][10]
+ C=regfile[22][10] B=regfile[21][10] A=regfile[20][10]
XU1729 MXI4X1 $PINS Y=n326 S1=n3747 S0=n3770 D=regfile[7][10] C=regfile[6][10]
+ B=regfile[5][10] A=regfile[4][10]
XU1730 MXI4X1 $PINS Y=n330 S1=FE_OFN220_n3747 S0=n3770 D=regfile[23][11]
+ C=regfile[22][11] B=regfile[21][11] A=regfile[20][11]
XU1731 MXI4X1 $PINS Y=n334 S1=n3747 S0=n3771 D=regfile[7][11] C=regfile[6][11]
+ B=regfile[5][11] A=regfile[4][11]
XU1732 MXI4X1 $PINS Y=n338 S1=n3746 S0=n3771 D=regfile[23][12]
+ C=regfile[22][12] B=regfile[21][12] A=regfile[20][12]
XU1733 MXI4X1 $PINS Y=n342 S1=n3741 S0=n3769 D=regfile[7][12] C=regfile[6][12]
+ B=regfile[5][12] A=regfile[4][12]
XU1734 MXI4X1 $PINS Y=n346 S1=FE_OFN217_n3742 S0=n3771 D=regfile[23][13]
+ C=regfile[22][13] B=regfile[21][13] A=regfile[20][13]
XU1735 MXI4X1 $PINS Y=n350 S1=n3753 S0=n3771 D=regfile[7][13] C=regfile[6][13]
+ B=regfile[5][13] A=regfile[4][13]
XU1736 MXI4X1 $PINS Y=n354 S1=n3754 S0=n3772 D=regfile[23][14]
+ C=regfile[22][14] B=regfile[21][14] A=regfile[20][14]
XU1737 MXI4X1 $PINS Y=n358 S1=n3755 S0=n3772 D=regfile[7][14] C=regfile[6][14]
+ B=regfile[5][14] A=regfile[4][14]
XU1738 MXI4X1 $PINS Y=n362 S1=n3752 S0=n3772 D=regfile[23][15]
+ C=regfile[22][15] B=regfile[21][15] A=regfile[20][15]
XU1739 MXI4X1 $PINS Y=n366 S1=n3753 S0=n3769 D=regfile[7][15] C=regfile[6][15]
+ B=regfile[5][15] A=regfile[4][15]
XU1740 MXI4X1 $PINS Y=n370 S1=FE_OFN218_n3743 S0=n3758 D=regfile[23][16]
+ C=regfile[22][16] B=regfile[21][16] A=regfile[20][16]
XU1741 MXI4X1 $PINS Y=n374 S1=n3754 S0=n3758 D=regfile[7][16] C=regfile[6][16]
+ B=regfile[5][16] A=regfile[4][16]
XU1742 MXI4X1 $PINS Y=n378 S1=FE_OFN217_n3742 S0=n3758 D=regfile[23][17]
+ C=regfile[22][17] B=regfile[21][17] A=regfile[20][17]
XU1743 MXI4X1 $PINS Y=n382 S1=n3751 S0=n3758 D=regfile[7][17] C=regfile[6][17]
+ B=regfile[5][17] A=regfile[4][17]
XU1744 MXI4X1 $PINS Y=n386 S1=n3753 S0=n3759 D=regfile[23][18]
+ C=regfile[22][18] B=regfile[21][18] A=regfile[20][18]
XU1745 MXI4X1 $PINS Y=n390 S1=n3754 S0=n3759 D=regfile[7][18] C=regfile[6][18]
+ B=regfile[5][18] A=regfile[4][18]
XU1746 MXI4X1 $PINS Y=n394 S1=n3748 S0=n3759 D=regfile[23][19]
+ C=regfile[22][19] B=regfile[21][19] A=regfile[20][19]
XU1747 MXI4X1 $PINS Y=n398 S1=n3746 S0=n3759 D=regfile[7][19] C=regfile[6][19]
+ B=regfile[5][19] A=regfile[4][19]
XU1748 MXI4X1 $PINS Y=n402 S1=n3755 S0=n3760 D=regfile[23][20]
+ C=regfile[22][20] B=regfile[21][20] A=regfile[20][20]
XU1749 MXI4X1 $PINS Y=n406 S1=FE_OFN218_n3743 S0=n3760 D=regfile[7][20]
+ C=regfile[6][20] B=regfile[5][20] A=regfile[4][20]
XU1752 MXI4X1 $PINS Y=n410 S1=FE_OFN217_n3742 S0=n3760 D=regfile[23][21]
+ C=regfile[22][21] B=regfile[21][21] A=regfile[20][21]
XU1753 MXI4X1 $PINS Y=n414 S1=n3754 S0=n3760 D=regfile[7][21] C=regfile[6][21]
+ B=regfile[5][21] A=regfile[4][21]
XU1756 MXI4X1 $PINS Y=n418 S1=FE_OFN221_n3744 S0=n3760 D=regfile[23][22]
+ C=regfile[22][22] B=regfile[21][22] A=regfile[20][22]
XU1759 MXI4X1 $PINS Y=n422 S1=n3752 S0=n3761 D=regfile[7][22] C=regfile[6][22]
+ B=regfile[5][22] A=regfile[4][22]
XU1767 MXI4X1 $PINS Y=n426 S1=n3748 S0=n3761 D=regfile[23][23]
+ C=regfile[22][23] B=regfile[21][23] A=regfile[20][23]
XU1768 MXI4X1 $PINS Y=n430 S1=n3752 S0=n3761 D=regfile[7][23] C=regfile[6][23]
+ B=regfile[5][23] A=regfile[4][23]
XU1769 MXI4X1 $PINS Y=n434 S1=FE_OFN217_n3742 S0=n3761 D=regfile[23][24]
+ C=regfile[22][24] B=regfile[21][24] A=regfile[20][24]
XU1772 MXI4X1 $PINS Y=n438 S1=FE_OFN220_n3747 S0=n3762 D=regfile[7][24]
+ C=regfile[6][24] B=regfile[5][24] A=regfile[4][24]
XU2678 MXI4X1 $PINS Y=n442 S1=n3751 S0=n3762 D=regfile[23][25]
+ C=regfile[22][25] B=regfile[21][25] A=regfile[20][25]
XU2679 MXI4X1 $PINS Y=n446 S1=n3752 S0=n3762 D=regfile[7][25] C=regfile[6][25]
+ B=regfile[5][25] A=regfile[4][25]
XU2680 MXI4X1 $PINS Y=n450 S1=n3751 S0=n3762 D=regfile[23][26]
+ C=regfile[22][26] B=regfile[21][26] A=regfile[20][26]
XU2681 MXI4X1 $PINS Y=n454 S1=n3752 S0=n3763 D=regfile[7][26] C=regfile[6][26]
+ B=regfile[5][26] A=regfile[4][26]
XU2682 MXI4X1 $PINS Y=n458 S1=n3748 S0=n3763 D=regfile[23][27]
+ C=regfile[22][27] B=regfile[21][27] A=regfile[20][27]
XU2683 MXI4X1 $PINS Y=n462 S1=n3745 S0=n3763 D=regfile[7][27] C=regfile[6][27]
+ B=regfile[5][27] A=regfile[4][27]
XU2684 MXI4X1 $PINS Y=n466 S1=n3746 S0=n3763 D=regfile[23][28]
+ C=regfile[22][28] B=regfile[21][28] A=regfile[20][28]
XU2685 MXI4X1 $PINS Y=n470 S1=n3744 S0=n3764 D=regfile[7][28] C=regfile[6][28]
+ B=regfile[5][28] A=regfile[4][28]
XU2686 MXI4X1 $PINS Y=n474 S1=FE_OFN221_n3744 S0=n3764 D=regfile[23][29]
+ C=regfile[22][29] B=regfile[21][29] A=regfile[20][29]
XU2687 MXI4X1 $PINS Y=n478 S1=n3744 S0=n3764 D=regfile[7][29] C=regfile[6][29]
+ B=regfile[5][29] A=regfile[4][29]
XU2688 MXI4X1 $PINS Y=n482 S1=FE_OFN221_n3744 S0=n3764 D=regfile[23][30]
+ C=regfile[22][30] B=regfile[21][30] A=regfile[20][30]
XU2689 MXI4X1 $PINS Y=n486 S1=n3744 S0=n3765 D=regfile[7][30] C=regfile[6][30]
+ B=regfile[5][30] A=regfile[4][30]
XU2690 MXI4X1 $PINS Y=n490 S1=FE_OFN221_n3744 S0=n3765 D=regfile[23][31]
+ C=regfile[22][31] B=regfile[21][31] A=regfile[20][31]
XU2691 MXI4X1 $PINS Y=n494 S1=n3749 S0=n3772 D=regfile[7][31] C=regfile[6][31]
+ B=regfile[5][31] A=regfile[4][31]
XU2692 MXI4X1 $PINS Y=n3845 S1=n4275 S0=n4290 D=regfile[15][0] C=regfile[14][0]
+ B=regfile[13][0] A=regfile[12][0]
XU2693 MXI4X1 $PINS Y=n3853 S1=n4276 S0=n4291 D=regfile[15][1] C=regfile[14][1]
+ B=regfile[13][1] A=regfile[12][1]
XU2694 MXI4X1 $PINS Y=n3861 S1=n4268 S0=n4291 D=regfile[15][2] C=regfile[14][2]
+ B=regfile[13][2] A=regfile[12][2]
XU2695 MXI4X1 $PINS Y=n3869 S1=n4271 S0=n4292 D=regfile[15][3] C=regfile[14][3]
+ B=regfile[13][3] A=regfile[12][3]
XU2696 MXI4X1 $PINS Y=n3877 S1=FE_OFN213_n4271 S0=n4292 D=regfile[15][4]
+ C=regfile[14][4] B=regfile[13][4] A=regfile[12][4]
XU2697 MXI4X1 $PINS Y=n3885 S1=FE_OFN213_n4271 S0=n4293 D=regfile[15][5]
+ C=regfile[14][5] B=regfile[13][5] A=regfile[12][5]
XU2698 MXI4X1 $PINS Y=n3893 S1=FE_OFN215_n4272 S0=n4293 D=regfile[15][6]
+ C=regfile[14][6] B=regfile[13][6] A=regfile[12][6]
XU2699 MXI4X1 $PINS Y=n3901 S1=FE_OFN215_n4272 S0=n4293 D=regfile[15][7]
+ C=regfile[14][7] B=regfile[13][7] A=regfile[12][7]
XU2700 MXI4X1 $PINS Y=n3909 S1=FE_OFN215_n4272 S0=n4294 D=regfile[15][8]
+ C=regfile[14][8] B=regfile[13][8] A=regfile[12][8]
XU2701 MXI4X1 $PINS Y=n3917 S1=FE_OFN214_n4273 S0=n4294 D=regfile[15][9]
+ C=regfile[14][9] B=regfile[13][9] A=regfile[12][9]
XU2702 MXI4X1 $PINS Y=n3925 S1=FE_OFN214_n4273 S0=n4295 D=regfile[15][10]
+ C=regfile[14][10] B=regfile[13][10] A=regfile[12][10]
XU2703 MXI4X1 $PINS Y=n3933 S1=FE_OFN214_n4273 S0=n4295 D=regfile[15][11]
+ C=regfile[14][11] B=regfile[13][11] A=regfile[12][11]
XU2704 MXI4X1 $PINS Y=n3941 S1=n4266 S0=n4296 D=regfile[15][12]
+ C=regfile[14][12] B=regfile[13][12] A=regfile[12][12]
XU2705 MXI4X1 $PINS Y=n3949 S1=n4272 S0=n4296 D=regfile[15][13]
+ C=regfile[14][13] B=regfile[13][13] A=regfile[12][13]
XU2706 MXI4X1 $PINS Y=n3957 S1=n4273 S0=n4297 D=regfile[15][14]
+ C=regfile[14][14] B=regfile[13][14] A=regfile[12][14]
XU2707 MXI4X1 $PINS Y=n3965 S1=n4279 S0=n4297 D=regfile[15][15]
+ C=regfile[14][15] B=regfile[13][15] A=regfile[12][15]
XU2708 MXI4X1 $PINS Y=n3973 S1=n4270 S0=n4283 D=regfile[15][16]
+ C=regfile[14][16] B=regfile[13][16] A=regfile[12][16]
XU2709 MXI4X1 $PINS Y=n3981 S1=FE_OFN216_n4267 S0=n4283 D=regfile[15][17]
+ C=regfile[14][17] B=regfile[13][17] A=regfile[12][17]
XU2710 MXI4X1 $PINS Y=n3989 S1=n4268 S0=n4284 D=regfile[15][18]
+ C=regfile[14][18] B=regfile[13][18] A=regfile[12][18]
XU2711 MXI4X1 $PINS Y=n3997 S1=n4277 S0=n4284 D=regfile[15][19]
+ C=regfile[14][19] B=regfile[13][19] A=regfile[12][19]
XU2712 MXI4X1 $PINS Y=n4005 S1=FE_OFN216_n4267 S0=n4285 D=regfile[15][20]
+ C=regfile[14][20] B=regfile[13][20] A=regfile[12][20]
XU2713 MXI4X1 $PINS Y=n4013 S1=n4266 S0=n4285 D=regfile[15][21]
+ C=regfile[14][21] B=regfile[13][21] A=regfile[12][21]
XU2714 MXI4X1 $PINS Y=n4021 S1=FE_OFN216_n4267 S0=n4286 D=regfile[15][22]
+ C=regfile[14][22] B=regfile[13][22] A=regfile[12][22]
XU2715 MXI4X1 $PINS Y=n4029 S1=n4278 S0=n4286 D=regfile[15][23]
+ C=regfile[14][23] B=regfile[13][23] A=regfile[12][23]
XU2716 MXI4X1 $PINS Y=n4037 S1=n4274 S0=n4287 D=regfile[15][24]
+ C=regfile[14][24] B=regfile[13][24] A=regfile[12][24]
XU2717 MXI4X1 $PINS Y=n4045 S1=n4270 S0=n4287 D=regfile[15][25]
+ C=regfile[14][25] B=regfile[13][25] A=regfile[12][25]
XU2718 MXI4X1 $PINS Y=n4053 S1=n4275 S0=n4288 D=regfile[15][26]
+ C=regfile[14][26] B=regfile[13][26] A=regfile[12][26]
XU2719 MXI4X1 $PINS Y=n4061 S1=n4278 S0=n4288 D=regfile[15][27]
+ C=regfile[14][27] B=regfile[13][27] A=regfile[12][27]
XU2720 MXI4X1 $PINS Y=n4069 S1=n4279 S0=n4288 D=regfile[15][28]
+ C=regfile[14][28] B=regfile[13][28] A=regfile[12][28]
XU2721 MXI4X1 $PINS Y=n4077 S1=n4279 S0=n4289 D=regfile[15][29]
+ C=regfile[14][29] B=regfile[13][29] A=regfile[12][29]
XU2722 MXI4X1 $PINS Y=n4085 S1=n4274 S0=n4289 D=regfile[15][30]
+ C=regfile[14][30] B=regfile[13][30] A=regfile[12][30]
XU2723 MXI4X1 $PINS Y=n4093 S1=n4266 S0=n4290 D=regfile[15][31]
+ C=regfile[14][31] B=regfile[13][31] A=regfile[12][31]
XU2724 MXI4X1 $PINS Y=n244 S1=n3745 S0=n3765 D=regfile[15][0] C=regfile[14][0]
+ B=regfile[13][0] A=regfile[12][0]
XU2725 MXI4X1 $PINS Y=n252 S1=FE_OFN222_n3745 S0=n3766 D=regfile[15][1]
+ C=regfile[14][1] B=regfile[13][1] A=regfile[12][1]
XU2726 MXI4X1 $PINS Y=n260 S1=n3745 S0=n3766 D=regfile[15][2] C=regfile[14][2]
+ B=regfile[13][2] A=regfile[12][2]
XU2727 MXI4X1 $PINS Y=n268 S1=n3754 S0=n3767 D=regfile[15][3] C=regfile[14][3]
+ B=regfile[13][3] A=regfile[12][3]
XU2728 MXI4X1 $PINS Y=n276 S1=n3741 S0=n3767 D=regfile[15][4] C=regfile[14][4]
+ B=regfile[13][4] A=regfile[12][4]
XU2729 MXI4X1 $PINS Y=n284 S1=n3751 S0=n3768 D=regfile[15][5] C=regfile[14][5]
+ B=regfile[13][5] A=regfile[12][5]
XU2730 MXI4X1 $PINS Y=n308 S1=n3751 S0=n3769 D=regfile[15][8] C=regfile[14][8]
+ B=regfile[13][8] A=regfile[12][8]
XU2731 MXI4X1 $PINS Y=n316 S1=n3747 S0=n3769 D=regfile[15][9] C=regfile[14][9]
+ B=regfile[13][9] A=regfile[12][9]
XU2732 MXI4X1 $PINS Y=n324 S1=n3747 S0=n3770 D=regfile[15][10]
+ C=regfile[14][10] B=regfile[13][10] A=regfile[12][10]
XU2733 MXI4X1 $PINS Y=n332 S1=FE_OFN220_n3747 S0=n3770 D=regfile[15][11]
+ C=regfile[14][11] B=regfile[13][11] A=regfile[12][11]
XU2734 MXI4X1 $PINS Y=n340 S1=FE_OFN218_n3743 S0=n3771 D=regfile[15][12]
+ C=regfile[14][12] B=regfile[13][12] A=regfile[12][12]
XU2735 MXI4X1 $PINS Y=n348 S1=n3755 S0=n3771 D=regfile[15][13]
+ C=regfile[14][13] B=regfile[13][13] A=regfile[12][13]
XU2736 MXI4X1 $PINS Y=n356 S1=FE_OFN217_n3742 S0=n3772 D=regfile[15][14]
+ C=regfile[14][14] B=regfile[13][14] A=regfile[12][14]
XU2737 MXI4X1 $PINS Y=n364 S1=n3749 S0=n3772 D=regfile[15][15]
+ C=regfile[14][15] B=regfile[13][15] A=regfile[12][15]
XU2738 MXI4X1 $PINS Y=n372 S1=n3752 S0=n3758 D=regfile[15][16]
+ C=regfile[14][16] B=regfile[13][16] A=regfile[12][16]
XU2739 MXI4X1 $PINS Y=n380 S1=n3748 S0=n3758 D=regfile[15][17]
+ C=regfile[14][17] B=regfile[13][17] A=regfile[12][17]
XU2740 MXI4X1 $PINS Y=n388 S1=FE_OFN217_n3742 S0=n3759 D=regfile[15][18]
+ C=regfile[14][18] B=regfile[13][18] A=regfile[12][18]
XU2741 MXI4X1 $PINS Y=n396 S1=n3752 S0=n3759 D=regfile[15][19]
+ C=regfile[14][19] B=regfile[13][19] A=regfile[12][19]
XU2742 MXI4X1 $PINS Y=n404 S1=FE_OFN217_n3742 S0=n3760 D=regfile[15][20]
+ C=regfile[14][20] B=regfile[13][20] A=regfile[12][20]
XU2743 MXI4X1 $PINS Y=n412 S1=n3746 S0=n3760 D=regfile[15][21]
+ C=regfile[14][21] B=regfile[13][21] A=regfile[12][21]
XU2744 MXI4X1 $PINS Y=n420 S1=n3744 S0=n3761 D=regfile[15][22]
+ C=regfile[14][22] B=regfile[13][22] A=regfile[12][22]
XU2745 MXI4X1 $PINS Y=n428 S1=n3753 S0=n3761 D=regfile[15][23]
+ C=regfile[14][23] B=regfile[13][23] A=regfile[12][23]
XU2746 MXI4X1 $PINS Y=n436 S1=n3744 S0=n3762 D=regfile[15][24]
+ C=regfile[14][24] B=regfile[13][24] A=regfile[12][24]
XU2747 MXI4X1 $PINS Y=n444 S1=n3751 S0=n3762 D=regfile[15][25]
+ C=regfile[14][25] B=regfile[13][25] A=regfile[12][25]
XU2748 MXI4X1 $PINS Y=n452 S1=n3751 S0=n3763 D=regfile[15][26]
+ C=regfile[14][26] B=regfile[13][26] A=regfile[12][26]
XU2749 MXI4X1 $PINS Y=n460 S1=FE_OFN218_n3743 S0=n3763 D=regfile[15][27]
+ C=regfile[14][27] B=regfile[13][27] A=regfile[12][27]
XU2750 MXI4X1 $PINS Y=n468 S1=n3744 S0=n3763 D=regfile[15][28]
+ C=regfile[14][28] B=regfile[13][28] A=regfile[12][28]
XU2751 MXI4X1 $PINS Y=n476 S1=n3744 S0=n3764 D=regfile[15][29]
+ C=regfile[14][29] B=regfile[13][29] A=regfile[12][29]
XU2752 MXI4X1 $PINS Y=n484 S1=n3744 S0=n3764 D=regfile[15][30]
+ C=regfile[14][30] B=regfile[13][30] A=regfile[12][30]
XU2753 MXI4X1 $PINS Y=n492 S1=n3745 S0=n3765 D=regfile[15][31]
+ C=regfile[14][31] B=regfile[13][31] A=regfile[12][31]
XU2754 MXI4X1 $PINS Y=n3846 S1=n4278 S0=n4290 D=regfile[11][0] C=regfile[10][0]
+ B=regfile[9][0] A=regfile[8][0]
XU2755 MXI4X1 $PINS Y=n3854 S1=n4275 S0=n4291 D=regfile[11][1] C=regfile[10][1]
+ B=regfile[9][1] A=regfile[8][1]
XU2756 MXI4X1 $PINS Y=n3862 S1=n4268 S0=n4291 D=regfile[11][2] C=regfile[10][2]
+ B=regfile[9][2] A=regfile[8][2]
XU2757 MXI4X1 $PINS Y=n3870 S1=FE_OFN213_n4271 S0=n4292 D=regfile[11][3]
+ C=regfile[10][3] B=regfile[9][3] A=regfile[8][3]
XU2758 MXI4X1 $PINS Y=n3878 S1=FE_OFN213_n4271 S0=n4292 D=regfile[11][4]
+ C=regfile[10][4] B=regfile[9][4] A=regfile[8][4]
XU2759 MXI4X1 $PINS Y=n3886 S1=FE_OFN213_n4271 S0=n4293 D=regfile[11][5]
+ C=regfile[10][5] B=regfile[9][5] A=regfile[8][5]
XU2760 MXI4X1 $PINS Y=n3894 S1=FE_OFN215_n4272 S0=n4293 D=regfile[11][6]
+ C=regfile[10][6] B=regfile[9][6] A=regfile[8][6]
XU2761 MXI4X1 $PINS Y=n3902 S1=FE_OFN215_n4272 S0=n4294 D=regfile[11][7]
+ C=regfile[10][7] B=regfile[9][7] A=regfile[8][7]
XU2762 MXI4X1 $PINS Y=n3910 S1=FE_OFN215_n4272 S0=n4294 D=regfile[11][8]
+ C=regfile[10][8] B=regfile[9][8] A=regfile[8][8]
XU2763 MXI4X1 $PINS Y=n3918 S1=FE_OFN214_n4273 S0=n4295 D=regfile[11][9]
+ C=regfile[10][9] B=regfile[9][9] A=regfile[8][9]
XU2764 MXI4X1 $PINS Y=n3926 S1=FE_OFN214_n4273 S0=n4295 D=regfile[11][10]
+ C=regfile[10][10] B=regfile[9][10] A=regfile[8][10]
XU2765 MXI4X1 $PINS Y=n3934 S1=FE_OFN214_n4273 S0=n4295 D=regfile[11][11]
+ C=regfile[10][11] B=regfile[9][11] A=regfile[8][11]
XU2766 MXI4X1 $PINS Y=n3942 S1=n4266 S0=n4296 D=regfile[11][12]
+ C=regfile[10][12] B=regfile[9][12] A=regfile[8][12]
XU2767 MXI4X1 $PINS Y=n3950 S1=n4272 S0=n4296 D=regfile[11][13]
+ C=regfile[10][13] B=regfile[9][13] A=regfile[8][13]
XU2768 MXI4X1 $PINS Y=n3958 S1=n4277 S0=n4297 D=regfile[11][14]
+ C=regfile[10][14] B=regfile[9][14] A=regfile[8][14]
XU2769 MXI4X1 $PINS Y=n3966 S1=FE_OFN216_n4267 S0=n4297 D=regfile[11][15]
+ C=regfile[10][15] B=regfile[9][15] A=regfile[8][15]
XU2770 MXI4X1 $PINS Y=n3974 S1=n4269 S0=n4283 D=regfile[11][16]
+ C=regfile[10][16] B=regfile[9][16] A=regfile[8][16]
XU2771 MXI4X1 $PINS Y=n3982 S1=FE_OFN216_n4267 S0=n4283 D=regfile[11][17]
+ C=regfile[10][17] B=regfile[9][17] A=regfile[8][17]
XU2772 MXI4X1 $PINS Y=n3990 S1=n4269 S0=n4284 D=regfile[11][18]
+ C=regfile[10][18] B=regfile[9][18] A=regfile[8][18]
XU2773 MXI4X1 $PINS Y=n3998 S1=n4274 S0=n4284 D=regfile[11][19]
+ C=regfile[10][19] B=regfile[9][19] A=regfile[8][19]
XU2774 MXI4X1 $PINS Y=n4006 S1=FE_OFN216_n4267 S0=n4285 D=regfile[11][20]
+ C=regfile[10][20] B=regfile[9][20] A=regfile[8][20]
XU2775 MXI4X1 $PINS Y=n4014 S1=n4266 S0=n4285 D=regfile[11][21]
+ C=regfile[10][21] B=regfile[9][21] A=regfile[8][21]
XU2776 MXI4X1 $PINS Y=n4022 S1=FE_OFN216_n4267 S0=n4286 D=regfile[11][22]
+ C=regfile[10][22] B=regfile[9][22] A=regfile[8][22]
XU2777 MXI4X1 $PINS Y=n4030 S1=n4278 S0=n4286 D=regfile[11][23]
+ C=regfile[10][23] B=regfile[9][23] A=regfile[8][23]
XU2778 MXI4X1 $PINS Y=n4038 S1=n4270 S0=n4287 D=regfile[11][24]
+ C=regfile[10][24] B=regfile[9][24] A=regfile[8][24]
XU2779 MXI4X1 $PINS Y=n4046 S1=n4279 S0=n4287 D=regfile[11][25]
+ C=regfile[10][25] B=regfile[9][25] A=regfile[8][25]
XU2780 MXI4X1 $PINS Y=n4054 S1=n4267 S0=n4288 D=regfile[11][26]
+ C=regfile[10][26] B=regfile[9][26] A=regfile[8][26]
XU2781 MXI4X1 $PINS Y=n4062 S1=n4267 S0=n4288 D=regfile[11][27]
+ C=regfile[10][27] B=regfile[9][27] A=regfile[8][27]
XU2782 MXI4X1 $PINS Y=n4070 S1=n4277 S0=n4289 D=regfile[11][28]
+ C=regfile[10][28] B=regfile[9][28] A=regfile[8][28]
XU2783 MXI4X1 $PINS Y=n4078 S1=n4275 S0=n4289 D=regfile[11][29]
+ C=regfile[10][29] B=regfile[9][29] A=regfile[8][29]
XU2784 MXI4X1 $PINS Y=n4086 S1=n4277 S0=n4289 D=regfile[11][30]
+ C=regfile[10][30] B=regfile[9][30] A=regfile[8][30]
XU2785 MXI4X1 $PINS Y=n4094 S1=n4266 S0=n4286 D=regfile[11][31]
+ C=regfile[10][31] B=regfile[9][31] A=regfile[8][31]
XU2786 MXI4X1 $PINS Y=n245 S1=n3745 S0=n3765 D=regfile[11][0] C=regfile[10][0]
+ B=regfile[9][0] A=regfile[8][0]
XU2787 MXI4X1 $PINS Y=n253 S1=n3745 S0=n3766 D=regfile[11][1] C=regfile[10][1]
+ B=regfile[9][1] A=regfile[8][1]
XU2788 MXI4X1 $PINS Y=n261 S1=n3745 S0=n3766 D=regfile[11][2] C=regfile[10][2]
+ B=regfile[9][2] A=regfile[8][2]
XU2789 MXI4X1 $PINS Y=n269 S1=n3755 S0=n3767 D=regfile[11][3] C=regfile[10][3]
+ B=regfile[9][3] A=regfile[8][3]
XU2790 MXI4X1 $PINS Y=n277 S1=n3753 S0=n3767 D=regfile[11][4] C=regfile[10][4]
+ B=regfile[9][4] A=regfile[8][4]
XU2791 MXI4X1 $PINS Y=n285 S1=n3752 S0=n3768 D=regfile[11][5] C=regfile[10][5]
+ B=regfile[9][5] A=regfile[8][5]
XU2792 MXI4X1 $PINS Y=n317 S1=n3747 S0=n3770 D=regfile[11][9] C=regfile[10][9]
+ B=regfile[9][9] A=regfile[8][9]
XU2793 MXI4X1 $PINS Y=n325 S1=n3747 S0=n3770 D=regfile[11][10]
+ C=regfile[10][10] B=regfile[9][10] A=regfile[8][10]
XU2794 MXI4X1 $PINS Y=n333 S1=n3747 S0=n3770 D=regfile[11][11]
+ C=regfile[10][11] B=regfile[9][11] A=regfile[8][11]
XU2795 MXI4X1 $PINS Y=n341 S1=n3751 S0=n3771 D=regfile[11][12]
+ C=regfile[10][12] B=regfile[9][12] A=regfile[8][12]
XU2796 MXI4X1 $PINS Y=n349 S1=n3742 S0=n3771 D=regfile[11][13]
+ C=regfile[10][13] B=regfile[9][13] A=regfile[8][13]
XU2797 MXI4X1 $PINS Y=n357 S1=n3754 S0=n3772 D=regfile[11][14]
+ C=regfile[10][14] B=regfile[9][14] A=regfile[8][14]
XU2798 MXI4X1 $PINS Y=n365 S1=n3749 S0=n3772 D=regfile[11][15]
+ C=regfile[10][15] B=regfile[9][15] A=regfile[8][15]
XU2799 MXI4X1 $PINS Y=n373 S1=n3746 S0=n3758 D=regfile[11][16]
+ C=regfile[10][16] B=regfile[9][16] A=regfile[8][16]
XU2800 MXI4X1 $PINS Y=n381 S1=FE_OFN218_n3743 S0=n3758 D=regfile[11][17]
+ C=regfile[10][17] B=regfile[9][17] A=regfile[8][17]
XU2801 MXI4X1 $PINS Y=n389 S1=n3754 S0=n3759 D=regfile[11][18]
+ C=regfile[10][18] B=regfile[9][18] A=regfile[8][18]
XU2802 MXI4X1 $PINS Y=n397 S1=n3753 S0=n3759 D=regfile[11][19]
+ C=regfile[10][19] B=regfile[9][19] A=regfile[8][19]
XU2803 MXI4X1 $PINS Y=n405 S1=n3746 S0=n3760 D=regfile[11][20]
+ C=regfile[10][20] B=regfile[9][20] A=regfile[8][20]
XU2804 MXI4X1 $PINS Y=n413 S1=n3752 S0=n3760 D=regfile[11][21]
+ C=regfile[10][21] B=regfile[9][21] A=regfile[8][21]
XU2805 MXI4X1 $PINS Y=n421 S1=n3752 S0=n3761 D=regfile[11][22]
+ C=regfile[10][22] B=regfile[9][22] A=regfile[8][22]
XU2806 MXI4X1 $PINS Y=n429 S1=n3751 S0=n3761 D=regfile[11][23]
+ C=regfile[10][23] B=regfile[9][23] A=regfile[8][23]
XU2807 MXI4X1 $PINS Y=n437 S1=n3744 S0=n3762 D=regfile[11][24]
+ C=regfile[10][24] B=regfile[9][24] A=regfile[8][24]
XU2808 MXI4X1 $PINS Y=n445 S1=n3752 S0=n3762 D=regfile[11][25]
+ C=regfile[10][25] B=regfile[9][25] A=regfile[8][25]
XU2809 MXI4X1 $PINS Y=n453 S1=n3754 S0=n3763 D=regfile[11][26]
+ C=regfile[10][26] B=regfile[9][26] A=regfile[8][26]
XU2810 MXI4X1 $PINS Y=n461 S1=n3747 S0=n3763 D=regfile[11][27]
+ C=regfile[10][27] B=regfile[9][27] A=regfile[8][27]
XU2811 MXI4X1 $PINS Y=n469 S1=n3744 S0=n3764 D=regfile[11][28]
+ C=regfile[10][28] B=regfile[9][28] A=regfile[8][28]
XU2812 MXI4X1 $PINS Y=n477 S1=n3744 S0=n3764 D=regfile[11][29]
+ C=regfile[10][29] B=regfile[9][29] A=regfile[8][29]
XU2813 MXI4X1 $PINS Y=n485 S1=n3744 S0=n3764 D=regfile[11][30]
+ C=regfile[10][30] B=regfile[9][30] A=regfile[8][30]
XU2814 MXI4X1 $PINS Y=n493 S1=n3753 S0=n3761 D=regfile[11][31]
+ C=regfile[10][31] B=regfile[9][31] A=regfile[8][31]
XU2815 NOR4X1 $PINS Y=n170 D=Instruction[30] C=Instruction[31]
+ B=Instruction[28] A=Instruction[29]
XU2816 OAI221XL $PINS Y=n3659 C0=n4577 B1=n1793 B0=n4952 A1=n4367 A0=n3657
XU2817 OA22X1 $PINS Y=n4577 B1=n4417 B0=n600 A1=n4576 A0=n4420
XU2818 CLKINVX1 $PINS Y=n4576 A=PCadd4[0]
XU2819 OAI221XL $PINS Y=n3660 C0=n4579 B1=n1793 B0=n4966 A1=n4367 A0=n3656
XU2820 OA22X1 $PINS Y=n4579 B1=n4417 B0=n599 A1=n4578 A0=n4420
XU2821 CLKINVX1 $PINS Y=n4578 A=PCadd4[1]
XU2822 OAI221XL $PINS Y=n3661 C0=n4581 B1=n1793 B0=n4934 A1=n4367 A0=n3655
XU2823 OA22X1 $PINS Y=n4581 B1=n4417 B0=n598 A1=n4580 A0=n4420
XU2824 OAI221XL $PINS Y=n3662 C0=n4583 B1=n1793 B0=n4943 A1=n4367 A0=n3654
XU2825 OA22X1 $PINS Y=n4583 B1=n4417 B0=n597 A1=n4582 A0=n4420
XU2826 OAI221XL $PINS Y=n3663 C0=n4585 B1=n1793 B0=n4913 A1=n4367 A0=n3653
XU2827 OA22X1 $PINS Y=n4585 B1=n4417 B0=SPCASCAN_N1 A1=n4584 A0=n4420
XU2828 OAI221XL $PINS Y=n3664 C0=n4587 B1=n1793 B0=n4922 A1=n4367 A0=n3652
XU2829 OA22X1 $PINS Y=n4587 B1=n4417 B0=SPCBSCAN_N38 A1=n4586 A0=n4420
XU2830 CLKINVX1 $PINS Y=n4586 A=PCadd4[5]
XU2831 OAI221XL $PINS Y=n3665 C0=n4589 B1=n1793 B0=n4895 A1=n4367 A0=n3651
XU2832 OA22X1 $PINS Y=n4589 B1=n4417 B0=n594 A1=n4588 A0=n4420
XU2833 CLKINVX1 $PINS Y=n4588 A=PCadd4[6]
XU2834 OAI221XL $PINS Y=n3666 C0=n4591 B1=n1793 B0=n4904 A1=n4367 A0=n3650
XU2835 OA22X1 $PINS Y=n4591 B1=n4417 B0=n593 A1=n4590 A0=n4420
XU2836 CLKINVX1 $PINS Y=n4590 A=PCadd4[7]
XU2837 OAI221XL $PINS Y=n3667 C0=n4593 B1=n1793 B0=n4874 A1=n4367 A0=n3649
XU2838 OA22X1 $PINS Y=n4593 B1=n4417 B0=SPCASCAN_N3 A1=n4592 A0=n4420
XU2839 CLKINVX1 $PINS Y=n4592 A=PCadd4[8]
XU2840 OAI221XL $PINS Y=n3668 C0=n4595 B1=n1793 B0=n4883 A1=n4367 A0=n3648
XU2841 OA22X1 $PINS Y=n4595 B1=n4417 B0=n591 A1=n4594 A0=n4420
XU2842 CLKINVX1 $PINS Y=n4594 A=PCadd4[9]
XU2843 OAI221XL $PINS Y=n3669 C0=n4597 B1=n1793 B0=n4856 A1=n4367 A0=n3647
XU2844 OA22X1 $PINS Y=n4597 B1=n4417 B0=n590 A1=n4596 A0=n4420
XU2845 CLKINVX1 $PINS Y=n4596 A=PCadd4[10]
XU2846 OAI221XL $PINS Y=n3670 C0=n4599 B1=n1793 B0=n4865 A1=n4367 A0=n3646
XU2847 OA22X1 $PINS Y=n4599 B1=n4417 B0=n589 A1=n4598 A0=n4420
XU2848 CLKINVX1 $PINS Y=n4598 A=PCadd4[11]
XU2849 OAI221XL $PINS Y=n3671 C0=n4601 B1=FE_OFN182_n1793 B0=n4834
+ A1=FE_OFN181_n4367 A0=n3645
XU2850 OA22X1 $PINS Y=n4601 B1=FE_OFN183_n4417 B0=n588 A1=n4600
+ A0=FE_OFN204_n4420
XU2851 CLKINVX1 $PINS Y=n4600 A=PCadd4[12]
XU2852 OAI221XL $PINS Y=n3672 C0=n4603 B1=FE_OFN182_n1793 B0=n4843
+ A1=FE_OFN181_n4367 A0=n3644
XU2853 OA22X1 $PINS Y=n4603 B1=FE_OFN183_n4417 B0=n587 A1=n4602
+ A0=FE_OFN204_n4420
XU2854 CLKINVX1 $PINS Y=n4602 A=PCadd4[13]
XU2855 OAI221XL $PINS Y=n3673 C0=n4605 B1=FE_OFN182_n1793 B0=n4816
+ A1=FE_OFN181_n4367 A0=n3643
XU2856 OA22X1 $PINS Y=n4605 B1=FE_OFN183_n4417 B0=n586 A1=n4604
+ A0=FE_OFN204_n4420
XU2857 CLKINVX1 $PINS Y=n4604 A=PCadd4[14]
XU2858 OAI221XL $PINS Y=n3674 C0=n4607 B1=FE_OFN182_n1793 B0=n4825
+ A1=FE_OFN181_n4367 A0=n3642
XU2859 OA22X1 $PINS Y=n4607 B1=FE_OFN183_n4417 B0=n585 A1=n4606
+ A0=FE_OFN204_n4420
XU2860 CLKINVX1 $PINS Y=n4606 A=PCadd4[15]
XU2861 OAI221XL $PINS Y=n3675 C0=n4609 B1=FE_OFN182_n1793 B0=n4790
+ A1=FE_OFN181_n4367 A0=n3641
XU2862 OA22X1 $PINS Y=n4609 B1=FE_OFN183_n4417 B0=n584 A1=n4608
+ A0=FE_OFN204_n4420
XU2863 CLKINVX1 $PINS Y=n4608 A=PCadd4[16]
XU2864 OAI221XL $PINS Y=n3676 C0=n4611 B1=FE_OFN182_n1793 B0=n4799
+ A1=FE_OFN181_n4367 A0=n3640
XU2865 OA22X1 $PINS Y=n4611 B1=FE_OFN183_n4417 B0=n583 A1=n4610
+ A0=FE_OFN204_n4420
XU2866 CLKINVX1 $PINS Y=n4610 A=PCadd4[17]
XU2867 OAI221XL $PINS Y=n3677 C0=n4613 B1=FE_OFN182_n1793 B0=n4772
+ A1=FE_OFN181_n4367 A0=n3639
XU2868 OA22X1 $PINS Y=n4613 B1=FE_OFN183_n4417 B0=n582 A1=n4612
+ A0=FE_OFN204_n4420
XU2869 CLKINVX1 $PINS Y=n4612 A=PCadd4[18]
XU2870 OAI221XL $PINS Y=n3678 C0=n4615 B1=FE_OFN182_n1793 B0=n4781
+ A1=FE_OFN181_n4367 A0=n3638
XU2871 OA22X1 $PINS Y=n4615 B1=FE_OFN183_n4417 B0=n581 A1=n4614
+ A0=FE_OFN204_n4420
XU2872 CLKINVX1 $PINS Y=n4614 A=PCadd4[19]
XU2873 OAI221XL $PINS Y=n3679 C0=n4617 B1=FE_OFN182_n1793 B0=n4750
+ A1=FE_OFN181_n4367 A0=n3637
XU2874 OA22X1 $PINS Y=n4617 B1=FE_OFN183_n4417 B0=n580 A1=n4616
+ A0=FE_OFN204_n4420
XU2875 CLKINVX1 $PINS Y=n4616 A=PCadd4[20]
XU2876 OAI221XL $PINS Y=n3680 C0=n4619 B1=FE_OFN182_n1793 B0=n4759
+ A1=FE_OFN181_n4367 A0=n3636
XU2877 OA22X1 $PINS Y=n4619 B1=FE_OFN183_n4417 B0=n579 A1=n4618
+ A0=FE_OFN204_n4420
XU2878 CLKINVX1 $PINS Y=n4618 A=PCadd4[21]
XU2879 OAI221XL $PINS Y=n3681 C0=n4621 B1=FE_OFN182_n1793 B0=n4732
+ A1=FE_OFN181_n4367 A0=n3635
XU2880 OA22X1 $PINS Y=n4621 B1=FE_OFN183_n4417 B0=n578 A1=n4620
+ A0=FE_OFN204_n4420
XU2881 CLKINVX1 $PINS Y=n4620 A=PCadd4[22]
XU2882 OAI221XL $PINS Y=n3682 C0=n4623 B1=FE_OFN182_n1793 B0=n4741
+ A1=FE_OFN181_n4367 A0=n3634
XU2883 OA22X1 $PINS Y=n4623 B1=FE_OFN183_n4417 B0=n577 A1=n4622
+ A0=FE_OFN204_n4420
XU2884 CLKINVX1 $PINS Y=n4622 A=PCadd4[23]
XU2885 OAI221XL $PINS Y=n3683 C0=n4625 B1=FE_OFN182_n1793 B0=n4710 A1=n4367
+ A0=n3633
XU2886 OA22X1 $PINS Y=n4625 B1=FE_OFN183_n4417 B0=SPCASCAN_N5 A1=n4624 A0=n4420
XU2887 CLKINVX1 $PINS Y=n4624 A=PCadd4[24]
XU2888 OAI221XL $PINS Y=n3684 C0=n4627 B1=FE_OFN182_n1793 B0=n4719
+ A1=FE_OFN181_n4367 A0=n3632
XU2889 OA22X1 $PINS Y=n4627 B1=FE_OFN183_n4417 B0=n575 A1=n4626
+ A0=FE_OFN204_n4420
XU2890 CLKINVX1 $PINS Y=n4626 A=PCadd4[25]
XU2891 OAI221XL $PINS Y=n3685 C0=n4629 B1=FE_OFN182_n1793 B0=n4692
+ A1=FE_OFN181_n4367 A0=n3631
XU2892 OA22X1 $PINS Y=n4629 B1=FE_OFN183_n4417 B0=n574 A1=n4628
+ A0=FE_OFN204_n4420
XU2893 CLKINVX1 $PINS Y=n4628 A=PCadd4[26]
XU2894 OAI221XL $PINS Y=n3686 C0=n4631 B1=FE_OFN182_n1793 B0=n4701
+ A1=FE_OFN181_n4367 A0=n3630
XU2895 OA22X1 $PINS Y=n4631 B1=FE_OFN183_n4417 B0=n573 A1=n4630
+ A0=FE_OFN204_n4420
XU2896 CLKINVX1 $PINS Y=n4630 A=PCadd4[27]
XU2897 OAI221XL $PINS Y=n3687 C0=n4633 B1=FE_OFN182_n1793 B0=n4670
+ A1=FE_OFN181_n4367 A0=n3629
XU2898 OA22X1 $PINS Y=n4633 B1=FE_OFN183_n4417 B0=n572 A1=n4632
+ A0=FE_OFN204_n4420
XU2899 CLKINVX1 $PINS Y=n4632 A=PCadd4[28]
XU2900 OAI221XL $PINS Y=n3688 C0=n4635 B1=FE_OFN182_n1793 B0=n4679
+ A1=FE_OFN181_n4367 A0=n3628
XU2901 OA22X1 $PINS Y=n4635 B1=FE_OFN183_n4417 B0=n571 A1=n4634
+ A0=FE_OFN204_n4420
XU2902 CLKINVX1 $PINS Y=n4634 A=PCadd4[29]
XU2903 OAI221XL $PINS Y=n3689 C0=n4637 B1=FE_OFN182_n1793 B0=n4652 A1=n4644
+ A0=n3627
XU2904 OA22X1 $PINS Y=n4637 B1=FE_OFN183_n4417 B0=n570 A1=n4636
+ A0=FE_OFN204_n4420
XU2905 CLKINVX1 $PINS Y=n4636 A=PCadd4[30]
XU2906 OAI221XL $PINS Y=n3690 C0=n4642 B1=FE_OFN182_n1793 B0=n4661 A1=n4644
+ A0=n3626
XU2907 OA22X1 $PINS Y=n4642 B1=FE_OFN183_n4417 B0=n569 A1=n4641
+ A0=FE_OFN204_n4420
XU2908 CLKINVX1 $PINS Y=n4641 A=PCadd4[31]
XU2909 NOR2BX1 $PINS Y=n104 B=n4983 AN=Reg_W[4]
XU2910 CLKINVX1 $PINS Y=n4419 A=n192
XU2911 OAI221XL $PINS Y=n192 C0=n4420 B1=MEM_RegWrite B0=n1899 A1=n132 A0=n124
XU2912 NOR2BX1 $PINS Y=n57 B=Reg_W[0] AN=Reg_W[1]
XU2913 NOR2BX1 $PINS Y=n53 B=Reg_W[1] AN=Reg_W[0]
XU2914 NOR2X1 $PINS Y=n65 B=Reg_W[1] A=Reg_W[0]
XU2915 NOR2X1 $PINS Y=n61 B=Reg_W[4] A=n4983
XU2916 MXI2X1 $PINS Y=n1614 S0=n4303 B=n4399 A=n1612
XU2917 MXI2X1 $PINS Y=n1616 S0=n4303 B=n4410 A=n1611
XU2918 MXI2X1 $PINS Y=n1618 S0=n4303 B=n4397 A=n1610
XU2919 MXI2X1 $PINS Y=n1620 S0=n4303 B=n4398 A=n1609
XU2920 MXI2X1 $PINS Y=n1622 S0=n4303 B=n4395 A=n1608
XU2921 MXI2X1 $PINS Y=n1624 S0=n4303 B=n4396 A=n1607
XU2922 MXI2X1 $PINS Y=n1626 S0=n4303 B=n4393 A=n1606
XU2923 MXI2X1 $PINS Y=n1628 S0=n4303 B=n4394 A=n1605
XU2924 MXI2X1 $PINS Y=n1630 S0=n4303 B=n4391 A=n1604
XU2925 MXI2X1 $PINS Y=n1632 S0=n4303 B=n4392 A=n1603
XU2926 MXI2X1 $PINS Y=n1634 S0=n4303 B=n4389 A=n1602
XU2927 MXI2X1 $PINS Y=n1636 S0=n4303 B=n4390 A=n1601
XU2928 MXI2X1 $PINS Y=n1638 S0=FE_OFN193_n4303 B=n4387 A=n1600
XU2929 MXI2X1 $PINS Y=n1640 S0=FE_OFN193_n4303 B=n4388 A=n1599
XU2930 MXI2X1 $PINS Y=n1642 S0=FE_OFN193_n4303 B=n4385 A=n1598
XU2931 MXI2X1 $PINS Y=n1644 S0=FE_OFN193_n4303 B=n4386 A=n1597
XU2932 MXI2X1 $PINS Y=n1646 S0=FE_OFN193_n4303 B=n4383 A=n1596
XU2933 MXI2X1 $PINS Y=n1648 S0=FE_OFN193_n4303 B=n4384 A=n1595
XU2934 MXI2X1 $PINS Y=n1650 S0=FE_OFN193_n4303 B=n4381 A=n1594
XU2935 MXI2X1 $PINS Y=n1652 S0=FE_OFN193_n4303 B=n4382 A=n1593
XU2936 MXI2X1 $PINS Y=n1654 S0=FE_OFN193_n4303 B=n4379 A=n1592
XU2937 MXI2X1 $PINS Y=n1656 S0=FE_OFN193_n4303 B=n4380 A=n1591
XU2938 MXI2X1 $PINS Y=n1658 S0=FE_OFN193_n4303 B=n4377 A=n1590
XU2939 MXI2X1 $PINS Y=n1660 S0=FE_OFN193_n4303 B=n4378 A=n1589
XU2940 MXI2X1 $PINS Y=n1662 S0=n4303 B=n4375 A=n1588
XU2941 MXI2X1 $PINS Y=n1664 S0=FE_OFN193_n4303 B=n4376 A=n1587
XU2942 MXI2X1 $PINS Y=n1666 S0=n113 B=n4373 A=n1586
XU2943 MXI2X1 $PINS Y=n1668 S0=n113 B=n4374 A=n1585
XU2944 MXI2X1 $PINS Y=n1670 S0=n113 B=n4371 A=n1584
XU2945 MXI2X1 $PINS Y=n1672 S0=n113 B=n4372 A=n1583
XU2946 MXI2X1 $PINS Y=n1674 S0=n113 B=n4369 A=n1582
XU2947 MXI2X1 $PINS Y=n1676 S0=n113 B=n4370 A=n1581
XU2948 MXI2X1 $PINS Y=n1742 S0=n4307 B=n4399 A=n1548
XU2949 MXI2X1 $PINS Y=n1744 S0=n4307 B=n4410 A=n1547
XU2950 MXI2X1 $PINS Y=n1746 S0=n4307 B=n4397 A=n1546
XU2951 MXI2X1 $PINS Y=n1748 S0=n4307 B=n4398 A=n1545
XU2952 MXI2X1 $PINS Y=n1750 S0=n4307 B=n4395 A=n1544
XU2953 MXI2X1 $PINS Y=n1752 S0=n4307 B=n4396 A=n1543
XU2954 MXI2X1 $PINS Y=n1754 S0=n4307 B=n4393 A=n1542
XU2955 MXI2X1 $PINS Y=n1756 S0=n4307 B=n4394 A=n1541
XU2956 MXI2X1 $PINS Y=n1758 S0=n4307 B=n4391 A=n1540
XU2957 MXI2X1 $PINS Y=n1760 S0=n4307 B=n4392 A=n1539
XU2958 MXI2X1 $PINS Y=n1762 S0=n4307 B=n4389 A=n1895
XU2959 MXI2X1 $PINS Y=n1764 S0=n4307 B=n4390 A=n1537
XU2960 MXI2X1 $PINS Y=n1766 S0=FE_OFN184_n4307 B=n4387 A=SPCASCAN_N33
XU2961 MXI2X1 $PINS Y=n1768 S0=FE_OFN184_n4307 B=n4388 A=n1535
XU2962 MXI2X1 $PINS Y=n1770 S0=FE_OFN184_n4307 B=n4385 A=n1534
XU2963 MXI2X1 $PINS Y=n1772 S0=FE_OFN184_n4307 B=n4386 A=n1533
XU2964 MXI2X1 $PINS Y=n1774 S0=FE_OFN184_n4307 B=n4383 A=n1532
XU2965 MXI2X1 $PINS Y=n1776 S0=FE_OFN184_n4307 B=n4384 A=n1531
XU2966 MXI2X1 $PINS Y=n1778 S0=FE_OFN184_n4307 B=n4381 A=n1530
XU2967 MXI2X1 $PINS Y=n1780 S0=FE_OFN184_n4307 B=n4382 A=n1529
XU2968 MXI2X1 $PINS Y=n1782 S0=FE_OFN184_n4307 B=n4379 A=n1528
XU2969 MXI2X1 $PINS Y=n1784 S0=FE_OFN184_n4307 B=n4380 A=n1527
XU2970 MXI2X1 $PINS Y=n1786 S0=FE_OFN184_n4307 B=n4377 A=n1526
XU2971 MXI2X1 $PINS Y=n1788 S0=FE_OFN184_n4307 B=n4378 A=n1525
XU2972 MXI2X1 $PINS Y=n1790 S0=n4307 B=n4375 A=n1524
XU2973 MXI2X1 $PINS Y=n1792 S0=FE_OFN184_n4307 B=n4376 A=n1523
XU2974 MXI2X1 $PINS Y=n1794 S0=n105 B=n4373 A=n1522
XU2975 MXI2X1 $PINS Y=n1796 S0=n105 B=n4374 A=n1521
XU2976 MXI2X1 $PINS Y=n1798 S0=n105 B=n4371 A=n1520
XU2977 MXI2X1 $PINS Y=n1800 S0=n105 B=n4372 A=n1519
XU2978 MXI2X1 $PINS Y=n1802 S0=n105 B=n4369 A=n1518
XU2979 MXI2X1 $PINS Y=n1804 S0=n105 B=n4370 A=n1517
XU2980 MXI2X1 $PINS Y=n1806 S0=n4309 B=n4399 A=n1516
XU2981 MXI2X1 $PINS Y=n1808 S0=n4309 B=n4410 A=n1515
XU2982 MXI2X1 $PINS Y=n1810 S0=n4309 B=n4397 A=n1514
XU2983 MXI2X1 $PINS Y=n1812 S0=n4309 B=n4398 A=n1513
XU2984 MXI2X1 $PINS Y=n1814 S0=n4309 B=n4395 A=n1512
XU2985 MXI2X1 $PINS Y=n1816 S0=n4309 B=n4396 A=n1511
XU2986 MXI2X1 $PINS Y=n1818 S0=n4309 B=n4393 A=n1510
XU2987 MXI2X1 $PINS Y=n1820 S0=n4309 B=n4394 A=n1509
XU2988 MXI2X1 $PINS Y=n1822 S0=n4309 B=n4391 A=n1508
XU2989 MXI2X1 $PINS Y=n1824 S0=n4309 B=n4392 A=n1507
XU2990 MXI2X1 $PINS Y=n1826 S0=n4309 B=n4389 A=n1506
XU2991 MXI2X1 $PINS Y=n1828 S0=n4309 B=n4390 A=n1505
XU2992 MXI2X1 $PINS Y=n1830 S0=n4310 B=n4387 A=n1504
XU2993 MXI2X1 $PINS Y=n1832 S0=n4310 B=n4388 A=n1503
XU2994 MXI2X1 $PINS Y=n1834 S0=n4310 B=n4385 A=n1502
XU2995 MXI2X1 $PINS Y=n1836 S0=n4310 B=n4386 A=n1501
XU2996 MXI2X1 $PINS Y=n1838 S0=n4310 B=n4383 A=n1500
XU2997 MXI2X1 $PINS Y=n1840 S0=n4310 B=n4384 A=n1499
XU2998 MXI2X1 $PINS Y=n1842 S0=n4310 B=n4381 A=n1498
XU2999 MXI2X1 $PINS Y=n1844 S0=n4310 B=n4382 A=n1497
XU3000 MXI2X1 $PINS Y=n1846 S0=n4310 B=n4379 A=n1496
XU3001 MXI2X1 $PINS Y=n1848 S0=n4310 B=n4380 A=n1495
XU3002 MXI2X1 $PINS Y=n1850 S0=n4310 B=n4377 A=n1494
XU3003 MXI2X1 $PINS Y=n1852 S0=n4310 B=n4378 A=n1493
XU3004 MXI2X1 $PINS Y=n1854 S0=n4309 B=n4375 A=n1492
XU3005 MXI2X1 $PINS Y=n1856 S0=n4310 B=n4376 A=n1491
XU3006 MXI2X1 $PINS Y=n1858 S0=n115 B=n4373 A=n1490
XU3007 MXI2X1 $PINS Y=n1860 S0=n115 B=n4374 A=n1489
XU3008 MXI2X1 $PINS Y=n1862 S0=n115 B=n4371 A=n1488
XU3009 MXI2X1 $PINS Y=n1864 S0=n115 B=n4372 A=n1487
XU3010 MXI2X1 $PINS Y=n1866 S0=n115 B=n4369 A=n1486
XU3011 MXI2X1 $PINS Y=n1868 S0=n115 B=n4370 A=n1485
XU3012 MXI2X1 $PINS Y=n1870 S0=n4311 B=n4399 A=n1484
XU3013 MXI2X1 $PINS Y=n1872 S0=n4311 B=n4410 A=n1483
XU3014 MXI2X1 $PINS Y=n1874 S0=n4311 B=n4397 A=n1482
XU3015 MXI2X1 $PINS Y=n1876 S0=n4311 B=n4398 A=n1481
XU3016 MXI2X1 $PINS Y=n1878 S0=n4311 B=n4395 A=n1480
XU3017 MXI2X1 $PINS Y=n1880 S0=n4311 B=n4396 A=n1479
XU3018 MXI2X1 $PINS Y=n1882 S0=n4311 B=n4393 A=n1478
XU3019 MXI2X1 $PINS Y=n1884 S0=n4311 B=n4394 A=n1477
XU3020 MXI2X1 $PINS Y=n1886 S0=n4311 B=n4391 A=n1476
XU3021 MXI2X1 $PINS Y=n1888 S0=n4311 B=n4392 A=n1475
XU3022 MXI2X1 $PINS Y=n1890 S0=n4311 B=n4389 A=n1474
XU3023 MXI2X1 $PINS Y=n1892 S0=n4311 B=n4390 A=n1473
XU3024 MXI2X1 $PINS Y=n1894 S0=n4312 B=n4387 A=n1472
XU3025 MXI2X1 $PINS Y=n1896 S0=n4312 B=n4388 A=n1471
XU3026 MXI2X1 $PINS Y=n1898 S0=n4312 B=n4385 A=n1470
XU3027 MXI2X1 $PINS Y=n1900 S0=n4312 B=n4386 A=n1469
XU3028 MXI2X1 $PINS Y=n1902 S0=n4312 B=n4383 A=n1468
XU3029 MXI2X1 $PINS Y=n1904 S0=n4312 B=n4384 A=n1467
XU3030 MXI2X1 $PINS Y=n1906 S0=n4312 B=n4381 A=n1466
XU3031 MXI2X1 $PINS Y=n1908 S0=n4312 B=n4382 A=n1465
XU3032 MXI2X1 $PINS Y=n1910 S0=n4312 B=n4379 A=n1464
XU3033 MXI2X1 $PINS Y=n1912 S0=n4312 B=n4380 A=n1463
XU3034 MXI2X1 $PINS Y=n1914 S0=n4312 B=n4377 A=n1462
XU3035 MXI2X1 $PINS Y=n1916 S0=n4312 B=n4378 A=n1461
XU3036 MXI2X1 $PINS Y=n1918 S0=n4311 B=n4375 A=n1460
XU3037 MXI2X1 $PINS Y=n1920 S0=n4312 B=n4376 A=n1459
XU3038 MXI2X1 $PINS Y=n1922 S0=n135 B=n4373 A=n1458
XU3039 MXI2X1 $PINS Y=n1924 S0=n135 B=n4374 A=n1457
XU3040 MXI2X1 $PINS Y=n1926 S0=n135 B=n4371 A=n1456
XU3041 MXI2X1 $PINS Y=n1928 S0=n135 B=n4372 A=n1455
XU3042 MXI2X1 $PINS Y=n1930 S0=n135 B=n4369 A=n1454
XU3043 MXI2X1 $PINS Y=n1932 S0=n135 B=n4370 A=n1453
XU3044 MXI2X1 $PINS Y=n1934 S0=n4313 B=n4399 A=n1452
XU3045 MXI2X1 $PINS Y=n1936 S0=n4313 B=n4410 A=n1451
XU3046 MXI2X1 $PINS Y=n1938 S0=n4313 B=n4397 A=n1450
XU3047 MXI2X1 $PINS Y=n1940 S0=n4313 B=n4398 A=n1449
XU3048 MXI2X1 $PINS Y=n1942 S0=n4313 B=n4395 A=n1448
XU3049 MXI2X1 $PINS Y=n1944 S0=n4313 B=n4396 A=n1447
XU3050 MXI2X1 $PINS Y=n1946 S0=n4313 B=n4393 A=n1446
XU3051 MXI2X1 $PINS Y=n1948 S0=n4313 B=n4394 A=n1445
XU3052 MXI2X1 $PINS Y=n1950 S0=n4313 B=n4391 A=n1444
XU3053 MXI2X1 $PINS Y=n1952 S0=n4313 B=n4392 A=n1443
XU3054 MXI2X1 $PINS Y=n1954 S0=n4313 B=n4389 A=n1442
XU3055 MXI2X1 $PINS Y=n1956 S0=n4313 B=n4390 A=n1441
XU3056 MXI2X1 $PINS Y=n1958 S0=n4314 B=n4387 A=n1440
XU3057 MXI2X1 $PINS Y=n1960 S0=n4314 B=n4388 A=n1439
XU3058 MXI2X1 $PINS Y=n1962 S0=n4314 B=n4385 A=n1438
XU3059 MXI2X1 $PINS Y=n1964 S0=n4314 B=n4386 A=n1437
XU3060 MXI2X1 $PINS Y=n1966 S0=n4314 B=n4383 A=n1436
XU3061 MXI2X1 $PINS Y=n1968 S0=n4314 B=n4384 A=n1435
XU3062 MXI2X1 $PINS Y=n1970 S0=n4314 B=n4381 A=n1434
XU3063 MXI2X1 $PINS Y=n1972 S0=n4314 B=n4382 A=n1433
XU3064 MXI2X1 $PINS Y=n1974 S0=n4314 B=n4379 A=n1432
XU3065 MXI2X1 $PINS Y=n1976 S0=n4314 B=n4380 A=n1431
XU3066 MXI2X1 $PINS Y=n1978 S0=n4314 B=n4377 A=n1430
XU3067 MXI2X1 $PINS Y=n1980 S0=n4314 B=n4378 A=n1429
XU3068 MXI2X1 $PINS Y=n1982 S0=n4313 B=n4375 A=n1428
XU3069 MXI2X1 $PINS Y=n1984 S0=n4314 B=n4376 A=n1427
XU3070 MXI2X1 $PINS Y=n1986 S0=n126 B=n4373 A=n1426
XU3071 MXI2X1 $PINS Y=n1988 S0=n126 B=n4374 A=n1425
XU3072 MXI2X1 $PINS Y=n1990 S0=n126 B=n4371 A=n1424
XU3073 MXI2X1 $PINS Y=n1992 S0=n126 B=n4372 A=n1423
XU3074 MXI2X1 $PINS Y=n1994 S0=n126 B=n4369 A=n1422
XU3075 MXI2X1 $PINS Y=n1996 S0=n126 B=n4370 A=n1421
XU3076 MXI2X1 $PINS Y=n1998 S0=n4315 B=n4399 A=n1420
XU3077 MXI2X1 $PINS Y=n2000 S0=n4315 B=n4410 A=n1419
XU3078 MXI2X1 $PINS Y=n2002 S0=n4315 B=n4397 A=n1418
XU3079 MXI2X1 $PINS Y=n2004 S0=n4315 B=n4398 A=n1417
XU3080 MXI2X1 $PINS Y=n2006 S0=n4315 B=n4395 A=n1416
XU3081 MXI2X1 $PINS Y=n2008 S0=n4315 B=n4396 A=n1415
XU3082 MXI2X1 $PINS Y=n2010 S0=n4315 B=n4393 A=n1414
XU3083 MXI2X1 $PINS Y=n2012 S0=n4315 B=n4394 A=n1413
XU3084 MXI2X1 $PINS Y=n2014 S0=n4315 B=n4391 A=n1412
XU3085 MXI2X1 $PINS Y=n2016 S0=n4315 B=n4392 A=n1411
XU3086 MXI2X1 $PINS Y=n2018 S0=n4315 B=n4389 A=n1410
XU3087 MXI2X1 $PINS Y=n2020 S0=n4315 B=n4390 A=n1409
XU3088 MXI2X1 $PINS Y=n2022 S0=n4316 B=n4387 A=n1408
XU3089 MXI2X1 $PINS Y=n2024 S0=n4316 B=n4388 A=n1407
XU3090 MXI2X1 $PINS Y=n2026 S0=n4316 B=n4385 A=n1406
XU3091 MXI2X1 $PINS Y=n2028 S0=n4316 B=n4386 A=n1405
XU3092 MXI2X1 $PINS Y=n2030 S0=n4316 B=n4383 A=n1404
XU3093 MXI2X1 $PINS Y=n2032 S0=n4316 B=n4384 A=n1403
XU3094 MXI2X1 $PINS Y=n2034 S0=n4316 B=n4381 A=n1402
XU3095 MXI2X1 $PINS Y=n2036 S0=n4316 B=n4382 A=n1401
XU3096 MXI2X1 $PINS Y=n2038 S0=n4316 B=n4379 A=n1400
XU3097 MXI2X1 $PINS Y=n2040 S0=n4316 B=n4380 A=n1399
XU3098 MXI2X1 $PINS Y=n2042 S0=n4316 B=n4377 A=n1398
XU3099 MXI2X1 $PINS Y=n2044 S0=n4316 B=n4378 A=n1397
XU3100 MXI2X1 $PINS Y=n2046 S0=n4315 B=n4375 A=n1396
XU3101 MXI2X1 $PINS Y=n2048 S0=n4316 B=n4376 A=n1395
XU3102 MXI2X1 $PINS Y=n2050 S0=n106 B=n4373 A=n1394
XU3103 MXI2X1 $PINS Y=n2052 S0=n106 B=n4374 A=n1393
XU3104 MXI2X1 $PINS Y=n2054 S0=n106 B=n4371 A=n1392
XU3105 MXI2X1 $PINS Y=n2056 S0=n106 B=n4372 A=n1391
XU3106 MXI2X1 $PINS Y=n2058 S0=n106 B=n4369 A=n1390
XU3107 MXI2X1 $PINS Y=n2060 S0=n106 B=n4370 A=n1389
XU3108 MXI2X1 $PINS Y=n2062 S0=n4317 B=n4399 A=n1388
XU3109 MXI2X1 $PINS Y=n2064 S0=n4317 B=n4410 A=n1387
XU3110 MXI2X1 $PINS Y=n2066 S0=n4317 B=n4397 A=n1386
XU3111 MXI2X1 $PINS Y=n2068 S0=n4317 B=n4398 A=n1385
XU3112 MXI2X1 $PINS Y=n2070 S0=n4317 B=n4395 A=n1384
XU3113 MXI2X1 $PINS Y=n2072 S0=n4317 B=n4396 A=n1383
XU3114 MXI2X1 $PINS Y=n2074 S0=n4317 B=n4393 A=n1382
XU3115 MXI2X1 $PINS Y=n2076 S0=n4317 B=n4394 A=n1381
XU3116 MXI2X1 $PINS Y=n2078 S0=n4317 B=n4391 A=n1380
XU3117 MXI2X1 $PINS Y=n2080 S0=n4317 B=n4392 A=n1379
XU3118 MXI2X1 $PINS Y=n2082 S0=n4317 B=n4389 A=n1378
XU3119 MXI2X1 $PINS Y=n2084 S0=n4317 B=n4390 A=n1377
XU3120 MXI2X1 $PINS Y=n2086 S0=FE_OFN198_n4317 B=n4387 A=n1376
XU3121 MXI2X1 $PINS Y=n2088 S0=FE_OFN198_n4317 B=n4388 A=n1375
XU3122 MXI2X1 $PINS Y=n2090 S0=FE_OFN198_n4317 B=n4385 A=n1374
XU3123 MXI2X1 $PINS Y=n2092 S0=FE_OFN198_n4317 B=n4386 A=n1373
XU3124 MXI2X1 $PINS Y=n2094 S0=FE_OFN198_n4317 B=n4383 A=n1372
XU3125 MXI2X1 $PINS Y=n2096 S0=FE_OFN198_n4317 B=n4384 A=n1371
XU3126 MXI2X1 $PINS Y=n2098 S0=FE_OFN198_n4317 B=n4381 A=n1370
XU3127 MXI2X1 $PINS Y=n2100 S0=FE_OFN198_n4317 B=n4382 A=n1369
XU3128 MXI2X1 $PINS Y=n2102 S0=FE_OFN198_n4317 B=n4379 A=n1368
XU3129 MXI2X1 $PINS Y=n2104 S0=FE_OFN198_n4317 B=n4380 A=n1367
XU3130 MXI2X1 $PINS Y=n2106 S0=FE_OFN198_n4317 B=n4377 A=n1366
XU3131 MXI2X1 $PINS Y=n2108 S0=FE_OFN198_n4317 B=n4378 A=n1365
XU3132 MXI2X1 $PINS Y=n2110 S0=n4317 B=n4375 A=n1364
XU3133 MXI2X1 $PINS Y=n2112 S0=FE_OFN198_n4317 B=n4376 A=n1363
XU3134 MXI2X1 $PINS Y=n2114 S0=n116 B=n4373 A=n1362
XU3135 MXI2X1 $PINS Y=n2116 S0=n116 B=n4374 A=n1361
XU3136 MXI2X1 $PINS Y=n2118 S0=n116 B=n4371 A=n1360
XU3137 MXI2X1 $PINS Y=n2120 S0=n116 B=n4372 A=n1359
XU3138 MXI2X1 $PINS Y=n2122 S0=n116 B=n4369 A=n1358
XU3139 MXI2X1 $PINS Y=n2124 S0=n116 B=n4370 A=n1357
XU3140 MXI2X1 $PINS Y=n2126 S0=n4319 B=n4399 A=n1356
XU3141 MXI2X1 $PINS Y=n2128 S0=n4319 B=n4410 A=n1355
XU3142 MXI2X1 $PINS Y=n2130 S0=n4319 B=n4397 A=n1354
XU3143 MXI2X1 $PINS Y=n2132 S0=n4319 B=n4398 A=n1353
XU3144 MXI2X1 $PINS Y=n2134 S0=n4319 B=n4395 A=n1352
XU3145 MXI2X1 $PINS Y=n2136 S0=n4319 B=n4396 A=n1351
XU3146 MXI2X1 $PINS Y=n2138 S0=n4319 B=n4393 A=n1350
XU3147 MXI2X1 $PINS Y=n2140 S0=n4319 B=n4394 A=n1349
XU3148 MXI2X1 $PINS Y=n2142 S0=n4319 B=n4391 A=n1348
XU3149 MXI2X1 $PINS Y=n2144 S0=n4319 B=n4392 A=n1347
XU3150 MXI2X1 $PINS Y=n2146 S0=n4319 B=n4389 A=n1346
XU3151 MXI2X1 $PINS Y=n2148 S0=n4319 B=n4390 A=n1345
XU3152 MXI2X1 $PINS Y=n2150 S0=n4320 B=n4387 A=n1344
XU3153 MXI2X1 $PINS Y=n2152 S0=n4320 B=n4388 A=n1343
XU3154 MXI2X1 $PINS Y=n2154 S0=n4320 B=n4385 A=n1342
XU3155 MXI2X1 $PINS Y=n2156 S0=n4320 B=n4386 A=n1341
XU3156 MXI2X1 $PINS Y=n2158 S0=n4320 B=n4383 A=n1340
XU3157 MXI2X1 $PINS Y=n2160 S0=n4320 B=n4384 A=n1339
XU3158 MXI2X1 $PINS Y=n2162 S0=n4320 B=n4381 A=n1338
XU3159 MXI2X1 $PINS Y=n2164 S0=n4320 B=n4382 A=n1337
XU3160 MXI2X1 $PINS Y=n2166 S0=n4320 B=n4379 A=n1336
XU3161 MXI2X1 $PINS Y=n2168 S0=n4320 B=n4380 A=n1335
XU3162 MXI2X1 $PINS Y=n2170 S0=n4320 B=n4377 A=n1334
XU3163 MXI2X1 $PINS Y=n2172 S0=n4320 B=n4378 A=n1333
XU3164 MXI2X1 $PINS Y=n2174 S0=n4319 B=n4375 A=n1332
XU3165 MXI2X1 $PINS Y=n2176 S0=n4320 B=n4376 A=n1331
XU3166 MXI2X1 $PINS Y=n2178 S0=n136 B=n4373 A=n1330
XU3167 MXI2X1 $PINS Y=n2180 S0=n136 B=n4374 A=n1329
XU3168 MXI2X1 $PINS Y=n2182 S0=n136 B=n4371 A=n1328
XU3169 MXI2X1 $PINS Y=n2184 S0=n136 B=n4372 A=n1327
XU3170 MXI2X1 $PINS Y=n2186 S0=n136 B=n4369 A=n1326
XU3171 MXI2X1 $PINS Y=n2188 S0=n136 B=n4370 A=n1325
XU3172 MXI2X1 $PINS Y=n2190 S0=n4321 B=n4399 A=n1324
XU3173 MXI2X1 $PINS Y=n2192 S0=n4321 B=n4410 A=n1323
XU3174 MXI2X1 $PINS Y=n2194 S0=n4321 B=n4397 A=n1322
XU3175 MXI2X1 $PINS Y=n2196 S0=n4321 B=n4398 A=n1321
XU3176 MXI2X1 $PINS Y=n2198 S0=n4321 B=n4395 A=n1320
XU3177 MXI2X1 $PINS Y=n2200 S0=n4321 B=n4396 A=n1319
XU3178 MXI2X1 $PINS Y=n2202 S0=n4321 B=n4393 A=n1318
XU3179 MXI2X1 $PINS Y=n2204 S0=n4321 B=n4394 A=n1317
XU3180 MXI2X1 $PINS Y=n2206 S0=n4321 B=n4391 A=n1316
XU3181 MXI2X1 $PINS Y=n2208 S0=n4321 B=n4392 A=n1315
XU3182 MXI2X1 $PINS Y=n2210 S0=n4321 B=n4389 A=n1314
XU3183 MXI2X1 $PINS Y=n2212 S0=n4321 B=n4390 A=n1313
XU3184 MXI2X1 $PINS Y=n2214 S0=n4322 B=n4387 A=n1312
XU3185 MXI2X1 $PINS Y=n2216 S0=n4322 B=n4388 A=n1311
XU3186 MXI2X1 $PINS Y=n2218 S0=n4322 B=n4385 A=n1310
XU3187 MXI2X1 $PINS Y=n2220 S0=n4322 B=n4386 A=n1309
XU3188 MXI2X1 $PINS Y=n2222 S0=n4322 B=n4383 A=n1308
XU3189 MXI2X1 $PINS Y=n2224 S0=n4322 B=n4384 A=n1307
XU3190 MXI2X1 $PINS Y=n2226 S0=n4322 B=n4381 A=n1306
XU3191 MXI2X1 $PINS Y=n2228 S0=n4322 B=n4382 A=n1305
XU3192 MXI2X1 $PINS Y=n2230 S0=n4322 B=n4379 A=n1304
XU3193 MXI2X1 $PINS Y=n2232 S0=n4322 B=n4380 A=n1303
XU3194 MXI2X1 $PINS Y=n2234 S0=n4322 B=n4377 A=n1302
XU3195 MXI2X1 $PINS Y=n2236 S0=n4322 B=n4378 A=n1301
XU3196 MXI2X1 $PINS Y=n2238 S0=n4321 B=n4375 A=n1300
XU3197 MXI2X1 $PINS Y=n2240 S0=n4322 B=n4376 A=n1299
XU3198 MXI2X1 $PINS Y=n2242 S0=n127 B=n4373 A=n1298
XU3199 MXI2X1 $PINS Y=n2244 S0=n127 B=n4374 A=n1297
XU3200 MXI2X1 $PINS Y=n2246 S0=n127 B=n4371 A=n1296
XU3201 MXI2X1 $PINS Y=n2248 S0=n127 B=n4372 A=n1295
XU3202 MXI2X1 $PINS Y=n2250 S0=n127 B=n4369 A=n1294
XU3203 MXI2X1 $PINS Y=n2252 S0=n127 B=n4370 A=n1293
XU3204 MXI2X1 $PINS Y=n2254 S0=n4323 B=n4399 A=n1292
XU3205 MXI2X1 $PINS Y=n2256 S0=n4323 B=n4410 A=n1291
XU3206 MXI2X1 $PINS Y=n2258 S0=n4323 B=n4397 A=n1290
XU3207 MXI2X1 $PINS Y=n2260 S0=n4323 B=n4398 A=n1289
XU3208 MXI2X1 $PINS Y=n2262 S0=n4323 B=n4395 A=n1288
XU3209 MXI2X1 $PINS Y=n2264 S0=n4323 B=n4396 A=n1287
XU3210 MXI2X1 $PINS Y=n2266 S0=n4323 B=n4393 A=n1286
XU3211 MXI2X1 $PINS Y=n2268 S0=n4323 B=n4394 A=n1285
XU3212 MXI2X1 $PINS Y=n2270 S0=n4323 B=n4391 A=n1284
XU3213 MXI2X1 $PINS Y=n2272 S0=n4323 B=n4392 A=n1283
XU3214 MXI2X1 $PINS Y=n2274 S0=n4323 B=n4389 A=n1282
XU3215 MXI2X1 $PINS Y=n2276 S0=n4323 B=n4390 A=n1281
XU3216 MXI2X1 $PINS Y=n2278 S0=n4324 B=n4387 A=n1280
XU3217 MXI2X1 $PINS Y=n2280 S0=n4324 B=n4388 A=n1279
XU3218 MXI2X1 $PINS Y=n2282 S0=n4324 B=n4385 A=n1278
XU3219 MXI2X1 $PINS Y=n2284 S0=n4324 B=n4386 A=n1277
XU3220 MXI2X1 $PINS Y=n2286 S0=n4324 B=n4383 A=n1276
XU3221 MXI2X1 $PINS Y=n2288 S0=n4324 B=n4384 A=n1275
XU3222 MXI2X1 $PINS Y=n2290 S0=n4324 B=n4381 A=n1274
XU3223 MXI2X1 $PINS Y=n2292 S0=n4324 B=n4382 A=n1273
XU3224 MXI2X1 $PINS Y=n2294 S0=n4324 B=n4379 A=n1272
XU3225 MXI2X1 $PINS Y=n2296 S0=n4324 B=n4380 A=n1271
XU3226 MXI2X1 $PINS Y=n2298 S0=n4324 B=n4377 A=n1270
XU3227 MXI2X1 $PINS Y=n2300 S0=n4324 B=n4378 A=n1269
XU3228 MXI2X1 $PINS Y=n2302 S0=n4323 B=n4375 A=n1268
XU3229 MXI2X1 $PINS Y=n2304 S0=n4324 B=n4376 A=n1267
XU3230 MXI2X1 $PINS Y=n2306 S0=n108 B=n4373 A=n1266
XU3231 MXI2X1 $PINS Y=n2308 S0=n108 B=n4374 A=n1265
XU3232 MXI2X1 $PINS Y=n2310 S0=n108 B=n4371 A=n1264
XU3233 MXI2X1 $PINS Y=n2312 S0=n108 B=n4372 A=n1263
XU3234 MXI2X1 $PINS Y=n2314 S0=n108 B=n4369 A=n1262
XU3235 MXI2X1 $PINS Y=n2316 S0=n108 B=n4370 A=n1261
XU3236 MXI2X1 $PINS Y=n2318 S0=n4325 B=n4399 A=n1260
XU3237 MXI2X1 $PINS Y=n2320 S0=n4325 B=n4410 A=n1259
XU3238 MXI2X1 $PINS Y=n2322 S0=n4325 B=n4397 A=n1258
XU3239 MXI2X1 $PINS Y=n2324 S0=n4325 B=n4398 A=n1257
XU3240 MXI2X1 $PINS Y=n2326 S0=n4325 B=n4395 A=n1256
XU3241 MXI2X1 $PINS Y=n2328 S0=n4325 B=n4396 A=n1255
XU3242 MXI2X1 $PINS Y=n2330 S0=n4325 B=n4393 A=n1254
XU3243 MXI2X1 $PINS Y=n2332 S0=n4325 B=n4394 A=n1253
XU3244 MXI2X1 $PINS Y=n2334 S0=n4325 B=n4391 A=n1252
XU3245 MXI2X1 $PINS Y=n2336 S0=n4325 B=n4392 A=n1251
XU3246 MXI2X1 $PINS Y=n2338 S0=n4325 B=n4389 A=n1250
XU3247 MXI2X1 $PINS Y=n2340 S0=n4325 B=n4390 A=n1249
XU3248 MXI2X1 $PINS Y=n2342 S0=n4326 B=n4387 A=n1248
XU3249 MXI2X1 $PINS Y=n2344 S0=n4326 B=n4388 A=n1247
XU3250 MXI2X1 $PINS Y=n2346 S0=n4326 B=n4385 A=n1246
XU3251 MXI2X1 $PINS Y=n2348 S0=n4326 B=n4386 A=n1245
XU3252 MXI2X1 $PINS Y=n2350 S0=n4326 B=n4383 A=n1244
XU3253 MXI2X1 $PINS Y=n2352 S0=n4326 B=n4384 A=n1243
XU3254 MXI2X1 $PINS Y=n2354 S0=n4326 B=n4381 A=n1242
XU3255 MXI2X1 $PINS Y=n2356 S0=n4326 B=n4382 A=n1241
XU3256 MXI2X1 $PINS Y=n2358 S0=n4326 B=n4379 A=n1240
XU3257 MXI2X1 $PINS Y=n2360 S0=n4326 B=n4380 A=n1239
XU3258 MXI2X1 $PINS Y=n2362 S0=n4326 B=n4377 A=n1238
XU3259 MXI2X1 $PINS Y=n2364 S0=n4326 B=n4378 A=n1237
XU3260 MXI2X1 $PINS Y=n2366 S0=n4325 B=n4375 A=n1236
XU3261 MXI2X1 $PINS Y=n2368 S0=n4326 B=n4376 A=n1235
XU3262 MXI2X1 $PINS Y=n2370 S0=n118 B=n4373 A=n1234
XU3263 MXI2X1 $PINS Y=n2372 S0=n118 B=n4374 A=n1233
XU3264 MXI2X1 $PINS Y=n2374 S0=n118 B=n4371 A=n1232
XU3265 MXI2X1 $PINS Y=n2376 S0=n118 B=n4372 A=n1231
XU3266 MXI2X1 $PINS Y=n2378 S0=n118 B=n4369 A=n1230
XU3267 MXI2X1 $PINS Y=n2380 S0=n118 B=n4370 A=n1229
XU3268 MXI2X1 $PINS Y=n2382 S0=n4327 B=n4399 A=n1228
XU3269 MXI2X1 $PINS Y=n2384 S0=n4327 B=n4410 A=n1227
XU3270 MXI2X1 $PINS Y=n2386 S0=n4327 B=n4397 A=n1226
XU3271 MXI2X1 $PINS Y=n2388 S0=n4327 B=n4398 A=n1225
XU3272 MXI2X1 $PINS Y=n2390 S0=n4327 B=n4395 A=n1224
XU3273 MXI2X1 $PINS Y=n2392 S0=n4327 B=n4396 A=n1223
XU3274 MXI2X1 $PINS Y=n2394 S0=n4327 B=n4393 A=n1222
XU3275 MXI2X1 $PINS Y=n2396 S0=n4327 B=n4394 A=n1221
XU3276 MXI2X1 $PINS Y=n2398 S0=n4327 B=n4391 A=n1220
XU3277 MXI2X1 $PINS Y=n2400 S0=n4327 B=n4392 A=n1219
XU3278 MXI2X1 $PINS Y=n2402 S0=n4327 B=n4389 A=n1218
XU3279 MXI2X1 $PINS Y=n2404 S0=n4327 B=n4390 A=n1217
XU3280 MXI2X1 $PINS Y=n2406 S0=n4328 B=n4387 A=n1216
XU3281 MXI2X1 $PINS Y=n2408 S0=n4328 B=n4388 A=n1215
XU3282 MXI2X1 $PINS Y=n2410 S0=n4328 B=n4385 A=n1214
XU3283 MXI2X1 $PINS Y=n2412 S0=n4328 B=n4386 A=n1213
XU3284 MXI2X1 $PINS Y=n2414 S0=n4328 B=n4383 A=n1212
XU3285 MXI2X1 $PINS Y=n2416 S0=n4328 B=n4384 A=n1211
XU3286 MXI2X1 $PINS Y=n2418 S0=n4328 B=n4381 A=n1210
XU3287 MXI2X1 $PINS Y=n2420 S0=n4328 B=n4382 A=n1209
XU3288 MXI2X1 $PINS Y=n2422 S0=n4328 B=n4379 A=n1208
XU3289 MXI2X1 $PINS Y=n2424 S0=n4328 B=n4380 A=n1207
XU3290 MXI2X1 $PINS Y=n2426 S0=n4328 B=n4377 A=n1206
XU3291 MXI2X1 $PINS Y=n2428 S0=n4328 B=n4378 A=n1205
XU3292 MXI2X1 $PINS Y=n2430 S0=n4327 B=n4375 A=n1204
XU3293 MXI2X1 $PINS Y=n2432 S0=n4328 B=n4376 A=n1203
XU3294 MXI2X1 $PINS Y=n2434 S0=n137 B=n4373 A=n1202
XU3295 MXI2X1 $PINS Y=n2436 S0=n137 B=n4374 A=n1201
XU3296 MXI2X1 $PINS Y=n2438 S0=n137 B=n4371 A=n1200
XU3297 MXI2X1 $PINS Y=n2440 S0=n137 B=n4372 A=n1199
XU3298 MXI2X1 $PINS Y=n2442 S0=n137 B=n4369 A=n1198
XU3299 MXI2X1 $PINS Y=n2444 S0=n137 B=n4370 A=n1197
XU3300 MXI2X1 $PINS Y=n2446 S0=n4329 B=n4399 A=n1196
XU3301 MXI2X1 $PINS Y=n2448 S0=n4329 B=n4410 A=n1195
XU3302 MXI2X1 $PINS Y=n2450 S0=n4329 B=n4397 A=n1194
XU3303 MXI2X1 $PINS Y=n2452 S0=n4329 B=n4398 A=n1193
XU3304 MXI2X1 $PINS Y=n2454 S0=n4329 B=n4395 A=n1192
XU3305 MXI2X1 $PINS Y=n2456 S0=n4329 B=n4396 A=n1191
XU3306 MXI2X1 $PINS Y=n2458 S0=n4329 B=n4393 A=n1190
XU3307 MXI2X1 $PINS Y=n2460 S0=n4329 B=n4394 A=n1189
XU3308 MXI2X1 $PINS Y=n2462 S0=n4329 B=n4391 A=n1188
XU3309 MXI2X1 $PINS Y=n2464 S0=n4329 B=n4392 A=n1187
XU3310 MXI2X1 $PINS Y=n2466 S0=n4329 B=n4389 A=n1186
XU3311 MXI2X1 $PINS Y=n2468 S0=n4329 B=n4390 A=n1185
XU3312 MXI2X1 $PINS Y=n2470 S0=n4330 B=n4387 A=n1184
XU3313 MXI2X1 $PINS Y=n2472 S0=n4330 B=n4388 A=n1183
XU3314 MXI2X1 $PINS Y=n2474 S0=n4330 B=n4385 A=n1182
XU3315 MXI2X1 $PINS Y=n2476 S0=n4330 B=n4386 A=n1181
XU3316 MXI2X1 $PINS Y=n2478 S0=n4330 B=n4383 A=n1180
XU3317 MXI2X1 $PINS Y=n2480 S0=n4330 B=n4384 A=n1179
XU3318 MXI2X1 $PINS Y=n2482 S0=n4330 B=n4381 A=n1178
XU3319 MXI2X1 $PINS Y=n2484 S0=n4330 B=n4382 A=n1177
XU3320 MXI2X1 $PINS Y=n2486 S0=n4330 B=n4379 A=n1176
XU3321 MXI2X1 $PINS Y=n2488 S0=n4330 B=n4380 A=n1175
XU3322 MXI2X1 $PINS Y=n2490 S0=n4330 B=n4377 A=n1174
XU3323 MXI2X1 $PINS Y=n2492 S0=n4330 B=n4378 A=n1173
XU3324 MXI2X1 $PINS Y=n2494 S0=n4329 B=n4375 A=n1172
XU3325 MXI2X1 $PINS Y=n2496 S0=n4330 B=n4376 A=n1171
XU3326 MXI2X1 $PINS Y=n2498 S0=n128 B=n4373 A=n1170
XU3327 MXI2X1 $PINS Y=n2500 S0=n128 B=n4701 A=n1169
XU3328 MXI2X1 $PINS Y=n2502 S0=n128 B=n4670 A=n1168
XU3329 MXI2X1 $PINS Y=n2504 S0=n128 B=n4372 A=n1167
XU3330 MXI2X1 $PINS Y=n2506 S0=n128 B=n4369 A=n1166
XU3331 MXI2X1 $PINS Y=n2508 S0=n128 B=n4370 A=n1165
XU3332 MXI2X1 $PINS Y=n2510 S0=FE_OFN185_n4331 B=n4952 A=n1164
XU3333 MXI2X1 $PINS Y=n2512 S0=FE_OFN185_n4331 B=n4966 A=n1163
XU3334 MXI2X1 $PINS Y=n2514 S0=FE_OFN185_n4331 B=n4934 A=n1162
XU3335 MXI2X1 $PINS Y=n2516 S0=FE_OFN185_n4331 B=n4943 A=n1161
XU3336 MXI2X1 $PINS Y=n2518 S0=FE_OFN185_n4331 B=n4913 A=n1160
XU3337 MXI2X1 $PINS Y=n2520 S0=FE_OFN185_n4331 B=n4922 A=n1159
XU3338 MXI2X1 $PINS Y=n2522 S0=FE_OFN185_n4331 B=n4895 A=n1158
XU3339 MXI2X1 $PINS Y=n2524 S0=FE_OFN185_n4331 B=n4904 A=n1157
XU3340 MXI2X1 $PINS Y=n2526 S0=FE_OFN185_n4331 B=n4874 A=n1156
XU3341 MXI2X1 $PINS Y=n2528 S0=FE_OFN185_n4331 B=n4883 A=n1155
XU3342 MXI2X1 $PINS Y=n2530 S0=FE_OFN185_n4331 B=n4856 A=n1154
XU3343 MXI2X1 $PINS Y=n2532 S0=FE_OFN185_n4331 B=n4865 A=n1153
XU3344 MXI2X1 $PINS Y=n2534 S0=n4331 B=n4834 A=n1152
XU3345 MXI2X1 $PINS Y=n2536 S0=n4331 B=n4843 A=n1151
XU3346 MXI2X1 $PINS Y=n2538 S0=n4331 B=n4816 A=n1150
XU3347 MXI2X1 $PINS Y=n2540 S0=n4331 B=n4825 A=n1149
XU3348 MXI2X1 $PINS Y=n2542 S0=n4331 B=n4790 A=n1148
XU3349 MXI2X1 $PINS Y=n2544 S0=n4331 B=n4799 A=n1147
XU3350 MXI2X1 $PINS Y=n2546 S0=n4331 B=n4772 A=n1146
XU3351 MXI2X1 $PINS Y=n2548 S0=n4331 B=n4781 A=n1145
XU3352 MXI2X1 $PINS Y=n2550 S0=n4331 B=n4750 A=n1144
XU3353 MXI2X1 $PINS Y=n2552 S0=n4331 B=n4759 A=n1143
XU3354 MXI2X1 $PINS Y=n2554 S0=n4331 B=n4732 A=n1142
XU3355 MXI2X1 $PINS Y=n2556 S0=n4331 B=n4741 A=n1141
XU3356 MXI2X1 $PINS Y=n2558 S0=FE_OFN185_n4331 B=n4710 A=n1140
XU3357 MXI2X1 $PINS Y=n2560 S0=n4331 B=n4719 A=n1139
XU3358 MXI2X1 $PINS Y=n2562 S0=n109 B=n4692 A=n1138
XU3359 MXI2X1 $PINS Y=n2564 S0=n109 B=n4701 A=n1137
XU3360 MXI2X1 $PINS Y=n2566 S0=n109 B=n4670 A=n1136
XU3361 MXI2X1 $PINS Y=n2568 S0=n109 B=n4679 A=n1135
XU3362 MXI2X1 $PINS Y=n2570 S0=n109 B=n4652 A=n1134
XU3363 MXI2X1 $PINS Y=n2572 S0=n109 B=n4661 A=n1133
XU3364 MXI2X1 $PINS Y=n2574 S0=n4333 B=n4952 A=n1132
XU3365 MXI2X1 $PINS Y=n2576 S0=n4333 B=n4966 A=n1131
XU3366 MXI2X1 $PINS Y=n2578 S0=n4333 B=n4934 A=n1130
XU3367 MXI2X1 $PINS Y=n2580 S0=n4333 B=n4943 A=n1129
XU3368 MXI2X1 $PINS Y=n2582 S0=n4333 B=n4913 A=n1128
XU3369 MXI2X1 $PINS Y=n2584 S0=n4333 B=n4922 A=n1127
XU3370 MXI2X1 $PINS Y=n2586 S0=n4333 B=n4895 A=n1126
XU3371 MXI2X1 $PINS Y=n2588 S0=n4333 B=n4904 A=n1125
XU3372 MXI2X1 $PINS Y=n2590 S0=n4333 B=n4874 A=n1124
XU3373 MXI2X1 $PINS Y=n2592 S0=n4333 B=n4883 A=n1123
XU3374 MXI2X1 $PINS Y=n2594 S0=n4333 B=n4856 A=n1122
XU3375 MXI2X1 $PINS Y=n2596 S0=n4333 B=n4865 A=n1121
XU3376 MXI2X1 $PINS Y=n2598 S0=FE_OFN199_n4333 B=n4834 A=n1120
XU3377 MXI2X1 $PINS Y=n2600 S0=FE_OFN199_n4333 B=n4843 A=n1119
XU3378 MXI2X1 $PINS Y=n2602 S0=FE_OFN199_n4333 B=n4816 A=n1118
XU3379 MXI2X1 $PINS Y=n2604 S0=FE_OFN199_n4333 B=n4825 A=n1117
XU3380 MXI2X1 $PINS Y=n2606 S0=FE_OFN199_n4333 B=n4790 A=n1116
XU3381 MXI2X1 $PINS Y=n2608 S0=FE_OFN199_n4333 B=n4799 A=n1115
XU3382 MXI2X1 $PINS Y=n2610 S0=FE_OFN199_n4333 B=n4772 A=n1114
XU3383 MXI2X1 $PINS Y=n2612 S0=FE_OFN199_n4333 B=n4781 A=n1113
XU3384 MXI2X1 $PINS Y=n2614 S0=FE_OFN199_n4333 B=n4750 A=n1112
XU3385 MXI2X1 $PINS Y=n2616 S0=FE_OFN199_n4333 B=n4759 A=n1111
XU3386 MXI2X1 $PINS Y=n2618 S0=FE_OFN199_n4333 B=n4732 A=n1110
XU3387 MXI2X1 $PINS Y=n2620 S0=FE_OFN199_n4333 B=n4741 A=n1109
XU3388 MXI2X1 $PINS Y=n2622 S0=n4333 B=n4710 A=n1108
XU3389 MXI2X1 $PINS Y=n2624 S0=FE_OFN199_n4333 B=n4719 A=n1107
XU3390 MXI2X1 $PINS Y=n2626 S0=n119 B=n4692 A=n1106
XU3391 MXI2X1 $PINS Y=n2628 S0=n119 B=n4701 A=n1105
XU3392 MXI2X1 $PINS Y=n2630 S0=n119 B=n4670 A=n1104
XU3393 MXI2X1 $PINS Y=n2632 S0=n119 B=n4679 A=n1103
XU3394 MXI2X1 $PINS Y=n2634 S0=n119 B=n4652 A=n1102
XU3395 MXI2X1 $PINS Y=n2636 S0=n119 B=n4661 A=n1101
XU3396 MXI2X1 $PINS Y=n2638 S0=n4335 B=n4952 A=n1100
XU3397 MXI2X1 $PINS Y=n2640 S0=n4335 B=n4966 A=n1099
XU3398 MXI2X1 $PINS Y=n2642 S0=n4335 B=n4934 A=n1098
XU3399 MXI2X1 $PINS Y=n2644 S0=n4335 B=n4943 A=n1097
XU3400 MXI2X1 $PINS Y=n2646 S0=n4335 B=n4913 A=n1096
XU3401 MXI2X1 $PINS Y=n2648 S0=n4335 B=n4922 A=n1095
XU3402 MXI2X1 $PINS Y=n2650 S0=n4335 B=n4895 A=n1094
XU3403 MXI2X1 $PINS Y=n2652 S0=n4335 B=n4904 A=n1093
XU3404 MXI2X1 $PINS Y=n2654 S0=n4335 B=n4874 A=n1092
XU3405 MXI2X1 $PINS Y=n2656 S0=n4335 B=n4883 A=n1091
XU3406 MXI2X1 $PINS Y=n2658 S0=n4335 B=n4856 A=n1090
XU3407 MXI2X1 $PINS Y=n2660 S0=n4335 B=n4865 A=n1089
XU3408 MXI2X1 $PINS Y=n2662 S0=FE_OFN195_n4335 B=n4834 A=n1088
XU3409 MXI2X1 $PINS Y=n2664 S0=FE_OFN195_n4335 B=n4843 A=n1087
XU3410 MXI2X1 $PINS Y=n2666 S0=FE_OFN195_n4335 B=n4816 A=n1086
XU3411 MXI2X1 $PINS Y=n2668 S0=FE_OFN195_n4335 B=n4825 A=n1085
XU3412 MXI2X1 $PINS Y=n2670 S0=FE_OFN195_n4335 B=n4790 A=n1084
XU3413 MXI2X1 $PINS Y=n2672 S0=FE_OFN195_n4335 B=n4799 A=n1083
XU3414 MXI2X1 $PINS Y=n2674 S0=FE_OFN195_n4335 B=n4772 A=n1082
XU3415 MXI2X1 $PINS Y=n2676 S0=FE_OFN195_n4335 B=n4781 A=n1081
XU3416 MXI2X1 $PINS Y=n2678 S0=FE_OFN195_n4335 B=n4750 A=n1080
XU3417 MXI2X1 $PINS Y=n2680 S0=FE_OFN195_n4335 B=n4759 A=n1079
XU3418 MXI2X1 $PINS Y=n2682 S0=FE_OFN195_n4335 B=n4732 A=n1078
XU3419 MXI2X1 $PINS Y=n2684 S0=FE_OFN195_n4335 B=n4741 A=n1077
XU3420 MXI2X1 $PINS Y=n2686 S0=n4335 B=n4710 A=n1076
XU3421 MXI2X1 $PINS Y=n2688 S0=FE_OFN195_n4335 B=n4719 A=n1075
XU3422 MXI2X1 $PINS Y=n2690 S0=n138 B=n4692 A=n1074
XU3423 MXI2X1 $PINS Y=n2692 S0=n138 B=n4701 A=n1073
XU3424 MXI2X1 $PINS Y=n2694 S0=n138 B=n4670 A=n1072
XU3425 MXI2X1 $PINS Y=n2696 S0=n138 B=n4679 A=n1071
XU3426 MXI2X1 $PINS Y=n2698 S0=n138 B=n4652 A=n1070
XU3427 MXI2X1 $PINS Y=n2700 S0=n138 B=n4661 A=n1069
XU3428 MXI2X1 $PINS Y=n2702 S0=n4337 B=n4952 A=n1068
XU3429 MXI2X1 $PINS Y=n2704 S0=n4337 B=n4966 A=n1067
XU3430 MXI2X1 $PINS Y=n2706 S0=n4337 B=n4934 A=n1066
XU3431 MXI2X1 $PINS Y=n2708 S0=n4337 B=n4943 A=n1065
XU3432 MXI2X1 $PINS Y=n2710 S0=n4337 B=n4913 A=n1064
XU3433 MXI2X1 $PINS Y=n2712 S0=n4337 B=n4922 A=n1063
XU3434 MXI2X1 $PINS Y=n2714 S0=n4337 B=n4895 A=n1062
XU3435 MXI2X1 $PINS Y=n2716 S0=n4337 B=n4904 A=n1061
XU3436 MXI2X1 $PINS Y=n2718 S0=n4337 B=n4874 A=n1060
XU3437 MXI2X1 $PINS Y=n2720 S0=n4337 B=n4883 A=n1059
XU3438 MXI2X1 $PINS Y=n2722 S0=n4337 B=n4856 A=n1058
XU3439 MXI2X1 $PINS Y=n2724 S0=n4337 B=n4865 A=n1057
XU3440 MXI2X1 $PINS Y=n2726 S0=FE_OFN190_n4337 B=n4834 A=n1056
XU3441 MXI2X1 $PINS Y=n2728 S0=FE_OFN190_n4337 B=n4843 A=n1055
XU3442 MXI2X1 $PINS Y=n2730 S0=FE_OFN190_n4337 B=n4816 A=n1054
XU3443 MXI2X1 $PINS Y=n2732 S0=FE_OFN190_n4337 B=n4825 A=n1053
XU3444 MXI2X1 $PINS Y=n2734 S0=FE_OFN190_n4337 B=n4790 A=n1052
XU3445 MXI2X1 $PINS Y=n2736 S0=FE_OFN190_n4337 B=n4799 A=n1051
XU3446 MXI2X1 $PINS Y=n2738 S0=FE_OFN190_n4337 B=n4772 A=n1050
XU3447 MXI2X1 $PINS Y=n2740 S0=FE_OFN190_n4337 B=n4781 A=n1049
XU3448 MXI2X1 $PINS Y=n2742 S0=FE_OFN190_n4337 B=n4750 A=n1048
XU3449 MXI2X1 $PINS Y=n2744 S0=FE_OFN190_n4337 B=n4759 A=n1047
XU3450 MXI2X1 $PINS Y=n2746 S0=FE_OFN190_n4337 B=n4732 A=n1046
XU3451 MXI2X1 $PINS Y=n2748 S0=FE_OFN190_n4337 B=n4741 A=n1045
XU3452 MXI2X1 $PINS Y=n2750 S0=n4337 B=n4710 A=n1044
XU3453 MXI2X1 $PINS Y=n2752 S0=FE_OFN190_n4337 B=n4719 A=n1043
XU3454 MXI2X1 $PINS Y=n2754 S0=n129 B=n4692 A=n1042
XU3455 MXI2X1 $PINS Y=n2756 S0=n129 B=n4701 A=n1041
XU3456 MXI2X1 $PINS Y=n2758 S0=n129 B=n4670 A=n1040
XU3457 MXI2X1 $PINS Y=n2760 S0=n129 B=n4679 A=n1039
XU3458 MXI2X1 $PINS Y=n2762 S0=n129 B=n4652 A=n1038
XU3459 MXI2X1 $PINS Y=n2764 S0=n129 B=n4661 A=n1037
XU3460 MXI2X1 $PINS Y=n2766 S0=n4339 B=n4952 A=n1036
XU3461 MXI2X1 $PINS Y=n2768 S0=n4339 B=n4966 A=n1035
XU3462 MXI2X1 $PINS Y=n2770 S0=n4339 B=n4934 A=n1034
XU3463 MXI2X1 $PINS Y=n2772 S0=n4339 B=n4943 A=n1033
XU3464 MXI2X1 $PINS Y=n2774 S0=n4339 B=n4913 A=n1032
XU3465 MXI2X1 $PINS Y=n2776 S0=n4339 B=n4922 A=n1031
XU3466 MXI2X1 $PINS Y=n2778 S0=n4339 B=n4895 A=n1030
XU3467 MXI2X1 $PINS Y=n2780 S0=n4339 B=n4904 A=n1029
XU3468 MXI2X1 $PINS Y=n2782 S0=n4339 B=n4874 A=n1028
XU3469 MXI2X1 $PINS Y=n2784 S0=n4339 B=n4883 A=n1027
XU3470 MXI2X1 $PINS Y=n2786 S0=n4339 B=n4856 A=n1026
XU3471 MXI2X1 $PINS Y=n2788 S0=n4339 B=n4865 A=n1025
XU3472 MXI2X1 $PINS Y=n2790 S0=FE_OFN186_n4339 B=n4834 A=n1024
XU3473 MXI2X1 $PINS Y=n2792 S0=FE_OFN186_n4339 B=n4843 A=n1023
XU3474 MXI2X1 $PINS Y=n2794 S0=FE_OFN186_n4339 B=n4816 A=n1022
XU3475 MXI2X1 $PINS Y=n2796 S0=FE_OFN186_n4339 B=n4825 A=n1021
XU3476 MXI2X1 $PINS Y=n2798 S0=FE_OFN186_n4339 B=n4790 A=n1020
XU3477 MXI2X1 $PINS Y=n2800 S0=FE_OFN186_n4339 B=n4799 A=n1019
XU3478 MXI2X1 $PINS Y=n2802 S0=FE_OFN186_n4339 B=n4772 A=n1018
XU3479 MXI2X1 $PINS Y=n2804 S0=FE_OFN186_n4339 B=n4781 A=n1017
XU3480 MXI2X1 $PINS Y=n2806 S0=FE_OFN186_n4339 B=n4750 A=n1016
XU3481 MXI2X1 $PINS Y=n2808 S0=FE_OFN186_n4339 B=n4759 A=n1015
XU3482 MXI2X1 $PINS Y=n2810 S0=FE_OFN186_n4339 B=n4732 A=n1014
XU3483 MXI2X1 $PINS Y=n2812 S0=FE_OFN186_n4339 B=n4741 A=n1013
XU3484 MXI2X1 $PINS Y=n2814 S0=n4339 B=n4710 A=n1012
XU3485 MXI2X1 $PINS Y=n2816 S0=FE_OFN186_n4339 B=n4719 A=n1011
XU3486 MXI2X1 $PINS Y=n2818 S0=n110 B=n4692 A=n1010
XU3487 MXI2X1 $PINS Y=n2820 S0=n110 B=n4701 A=n1009
XU3488 MXI2X1 $PINS Y=n2822 S0=n110 B=n4670 A=n1008
XU3489 MXI2X1 $PINS Y=n2824 S0=n110 B=n4679 A=n1007
XU3490 MXI2X1 $PINS Y=n2826 S0=n110 B=n4652 A=n1006
XU3491 MXI2X1 $PINS Y=n2828 S0=n110 B=n4661 A=n1005
XU3492 MXI2X1 $PINS Y=n2830 S0=n4341 B=n4952 A=n1004
XU3493 MXI2X1 $PINS Y=n2832 S0=n4341 B=n4966 A=n1003
XU3494 MXI2X1 $PINS Y=n2834 S0=n4341 B=n4934 A=n1002
XU3495 MXI2X1 $PINS Y=n2836 S0=n4341 B=n4943 A=n1001
XU3496 MXI2X1 $PINS Y=n2838 S0=n4341 B=n4913 A=n1000
XU3497 MXI2X1 $PINS Y=n2840 S0=n4341 B=n4922 A=n999
XU3498 MXI2X1 $PINS Y=n2842 S0=n4341 B=n4895 A=n998
XU3499 MXI2X1 $PINS Y=n2844 S0=n4341 B=n4904 A=n997
XU3500 MXI2X1 $PINS Y=n2846 S0=n4341 B=n4874 A=n996
XU3501 MXI2X1 $PINS Y=n2848 S0=n4341 B=n4883 A=n995
XU3502 MXI2X1 $PINS Y=n2850 S0=n4341 B=n4856 A=n994
XU3503 MXI2X1 $PINS Y=n2852 S0=n4341 B=n4865 A=n993
XU3504 MXI2X1 $PINS Y=n2854 S0=FE_OFN200_n4341 B=n4834 A=n992
XU3505 MXI2X1 $PINS Y=n2856 S0=FE_OFN200_n4341 B=n4843 A=n991
XU3506 MXI2X1 $PINS Y=n2858 S0=FE_OFN200_n4341 B=n4816 A=n990
XU3507 MXI2X1 $PINS Y=n2860 S0=FE_OFN200_n4341 B=n4825 A=n989
XU3508 MXI2X1 $PINS Y=n2862 S0=FE_OFN200_n4341 B=n4790 A=n988
XU3509 MXI2X1 $PINS Y=n2864 S0=FE_OFN200_n4341 B=n4799 A=n987
XU3510 MXI2X1 $PINS Y=n2866 S0=FE_OFN200_n4341 B=n4772 A=n986
XU3511 MXI2X1 $PINS Y=n2868 S0=FE_OFN200_n4341 B=n4781 A=n985
XU3512 MXI2X1 $PINS Y=n2870 S0=FE_OFN200_n4341 B=n4750 A=n984
XU3513 MXI2X1 $PINS Y=n2872 S0=FE_OFN200_n4341 B=n4759 A=n983
XU3514 MXI2X1 $PINS Y=n2874 S0=FE_OFN200_n4341 B=n4732 A=n982
XU3515 MXI2X1 $PINS Y=n2876 S0=FE_OFN200_n4341 B=n4741 A=n981
XU3516 MXI2X1 $PINS Y=n2878 S0=n4341 B=n4710 A=n980
XU3517 MXI2X1 $PINS Y=n2880 S0=FE_OFN200_n4341 B=n4719 A=n979
XU3518 MXI2X1 $PINS Y=n2882 S0=n120 B=n4692 A=n978
XU3519 MXI2X1 $PINS Y=n2884 S0=n120 B=n4701 A=n977
XU3520 MXI2X1 $PINS Y=n2886 S0=n120 B=n4670 A=n976
XU3521 MXI2X1 $PINS Y=n2888 S0=n120 B=n4679 A=n975
XU3522 MXI2X1 $PINS Y=n2890 S0=n120 B=n4652 A=n974
XU3523 MXI2X1 $PINS Y=n2892 S0=n120 B=n4661 A=n973
XU3524 MXI2X1 $PINS Y=n2894 S0=n4343 B=n4952 A=n972
XU3525 MXI2X1 $PINS Y=n2896 S0=n4343 B=n4966 A=n971
XU3526 MXI2X1 $PINS Y=n2898 S0=n4343 B=n4934 A=n970
XU3527 MXI2X1 $PINS Y=n2900 S0=n4343 B=n4943 A=n969
XU3528 MXI2X1 $PINS Y=n2902 S0=n4343 B=n4913 A=n968
XU3529 MXI2X1 $PINS Y=n2904 S0=n4343 B=n4922 A=n967
XU3530 MXI2X1 $PINS Y=n2906 S0=n4343 B=n4895 A=n966
XU3531 MXI2X1 $PINS Y=n2908 S0=n4343 B=n4904 A=n965
XU3532 MXI2X1 $PINS Y=n2910 S0=n4343 B=n4874 A=n964
XU3533 MXI2X1 $PINS Y=n2912 S0=n4343 B=n4883 A=n963
XU3534 MXI2X1 $PINS Y=n2914 S0=n4343 B=n4856 A=n962
XU3535 MXI2X1 $PINS Y=n2916 S0=n4343 B=n4865 A=n961
XU3536 MXI2X1 $PINS Y=n2918 S0=FE_OFN196_n4343 B=n4834 A=n960
XU3537 MXI2X1 $PINS Y=n2920 S0=FE_OFN196_n4343 B=n4843 A=n959
XU3538 MXI2X1 $PINS Y=n2922 S0=FE_OFN196_n4343 B=n4816 A=n958
XU3539 MXI2X1 $PINS Y=n2924 S0=FE_OFN196_n4343 B=n4825 A=n957
XU3540 MXI2X1 $PINS Y=n2926 S0=FE_OFN196_n4343 B=n4790 A=n956
XU3541 MXI2X1 $PINS Y=n2928 S0=FE_OFN196_n4343 B=n4799 A=n955
XU3542 MXI2X1 $PINS Y=n2930 S0=FE_OFN196_n4343 B=n4772 A=n954
XU3543 MXI2X1 $PINS Y=n2932 S0=FE_OFN196_n4343 B=n4781 A=n953
XU3544 MXI2X1 $PINS Y=n2934 S0=FE_OFN196_n4343 B=n4750 A=n952
XU3545 MXI2X1 $PINS Y=n2936 S0=FE_OFN196_n4343 B=n4759 A=n951
XU3546 MXI2X1 $PINS Y=n2938 S0=FE_OFN196_n4343 B=n4732 A=n950
XU3547 MXI2X1 $PINS Y=n2940 S0=FE_OFN196_n4343 B=n4741 A=n949
XU3548 MXI2X1 $PINS Y=n2942 S0=n4343 B=n4710 A=n948
XU3549 MXI2X1 $PINS Y=n2944 S0=FE_OFN196_n4343 B=n4719 A=n947
XU3550 MXI2X1 $PINS Y=n2946 S0=n139 B=n4692 A=n946
XU3551 MXI2X1 $PINS Y=n2948 S0=n139 B=n4701 A=n945
XU3552 MXI2X1 $PINS Y=n2950 S0=n139 B=n4670 A=n944
XU3553 MXI2X1 $PINS Y=n2952 S0=n139 B=n4679 A=n943
XU3554 MXI2X1 $PINS Y=n2954 S0=n139 B=n4652 A=n942
XU3555 MXI2X1 $PINS Y=n2956 S0=n139 B=n4661 A=n941
XU3556 MXI2X1 $PINS Y=n2958 S0=n4345 B=n4952 A=n940
XU3557 MXI2X1 $PINS Y=n2960 S0=n4345 B=n4966 A=n939
XU3558 MXI2X1 $PINS Y=n2962 S0=n4345 B=n4934 A=n938
XU3559 MXI2X1 $PINS Y=n2964 S0=n4345 B=n4943 A=n937
XU3560 MXI2X1 $PINS Y=n2966 S0=n4345 B=n4913 A=n936
XU3561 MXI2X1 $PINS Y=n2968 S0=n4345 B=n4922 A=n935
XU3562 MXI2X1 $PINS Y=n2970 S0=n4345 B=n4895 A=n934
XU3563 MXI2X1 $PINS Y=n2972 S0=n4345 B=n4904 A=n933
XU3564 MXI2X1 $PINS Y=n2974 S0=n4345 B=n4874 A=n932
XU3565 MXI2X1 $PINS Y=n2976 S0=n4345 B=n4883 A=n931
XU3566 MXI2X1 $PINS Y=n2978 S0=n4345 B=n4856 A=n930
XU3567 MXI2X1 $PINS Y=n2980 S0=n4345 B=n4865 A=n929
XU3568 MXI2X1 $PINS Y=n2982 S0=FE_OFN191_n4345 B=n4834 A=n928
XU3569 MXI2X1 $PINS Y=n2984 S0=FE_OFN191_n4345 B=n4843 A=n927
XU3570 MXI2X1 $PINS Y=n2986 S0=FE_OFN191_n4345 B=n4816 A=n926
XU3571 MXI2X1 $PINS Y=n2988 S0=FE_OFN191_n4345 B=n4825 A=n925
XU3572 MXI2X1 $PINS Y=n2990 S0=FE_OFN191_n4345 B=n4790 A=n924
XU3573 MXI2X1 $PINS Y=n2992 S0=FE_OFN191_n4345 B=n4799 A=n923
XU3574 MXI2X1 $PINS Y=n2994 S0=FE_OFN191_n4345 B=n4772 A=n922
XU3575 MXI2X1 $PINS Y=n2996 S0=FE_OFN191_n4345 B=n4781 A=n921
XU3576 MXI2X1 $PINS Y=n2998 S0=FE_OFN191_n4345 B=n4750 A=n920
XU3577 MXI2X1 $PINS Y=n3000 S0=FE_OFN191_n4345 B=n4759 A=n919
XU3578 MXI2X1 $PINS Y=n3002 S0=FE_OFN191_n4345 B=n4732 A=n918
XU3579 MXI2X1 $PINS Y=n3004 S0=FE_OFN191_n4345 B=n4741 A=n917
XU3580 MXI2X1 $PINS Y=n3006 S0=n4345 B=n4710 A=n916
XU3581 MXI2X1 $PINS Y=n3008 S0=FE_OFN191_n4345 B=n4719 A=n915
XU3582 MXI2X1 $PINS Y=n3010 S0=n130 B=n4692 A=n914
XU3583 MXI2X1 $PINS Y=n3012 S0=n130 B=n4701 A=n913
XU3584 MXI2X1 $PINS Y=n3014 S0=n130 B=n4670 A=n912
XU3585 MXI2X1 $PINS Y=n3016 S0=n130 B=n4679 A=n911
XU3586 MXI2X1 $PINS Y=n3018 S0=n130 B=n4652 A=n910
XU3587 MXI2X1 $PINS Y=n3020 S0=n130 B=n4661 A=n909
XU3588 MXI2X1 $PINS Y=n3022 S0=n4347 B=n4952 A=n908
XU3589 MXI2X1 $PINS Y=n3024 S0=n4347 B=n4966 A=n907
XU3590 MXI2X1 $PINS Y=n3026 S0=n4347 B=n4934 A=n906
XU3591 MXI2X1 $PINS Y=n3028 S0=n4347 B=n4943 A=n905
XU3592 MXI2X1 $PINS Y=n3030 S0=n4347 B=n4913 A=n904
XU3593 MXI2X1 $PINS Y=n3032 S0=n4347 B=n4922 A=n903
XU3594 MXI2X1 $PINS Y=n3034 S0=n4347 B=n4895 A=n902
XU3595 MXI2X1 $PINS Y=n3036 S0=n4347 B=n4904 A=n901
XU3596 MXI2X1 $PINS Y=n3038 S0=n4347 B=n4874 A=n900
XU3597 MXI2X1 $PINS Y=n3040 S0=n4347 B=n4883 A=n899
XU3598 MXI2X1 $PINS Y=n3042 S0=n4347 B=n4856 A=n898
XU3599 MXI2X1 $PINS Y=n3044 S0=n4347 B=n4865 A=n897
XU3600 MXI2X1 $PINS Y=n3046 S0=FE_OFN187_n4347 B=n4834 A=n896
XU3601 MXI2X1 $PINS Y=n3048 S0=FE_OFN187_n4347 B=n4843 A=n895
XU3602 MXI2X1 $PINS Y=n3050 S0=FE_OFN187_n4347 B=n4816 A=n894
XU3603 MXI2X1 $PINS Y=n3052 S0=FE_OFN187_n4347 B=n4825 A=n893
XU3604 MXI2X1 $PINS Y=n3054 S0=FE_OFN187_n4347 B=n4790 A=n892
XU3605 MXI2X1 $PINS Y=n3056 S0=FE_OFN187_n4347 B=n4799 A=n891
XU3606 MXI2X1 $PINS Y=n3058 S0=FE_OFN187_n4347 B=n4772 A=n890
XU3607 MXI2X1 $PINS Y=n3060 S0=FE_OFN187_n4347 B=n4781 A=n889
XU3608 MXI2X1 $PINS Y=n3062 S0=FE_OFN187_n4347 B=n4750 A=n888
XU3609 MXI2X1 $PINS Y=n3064 S0=FE_OFN187_n4347 B=n4759 A=n887
XU3610 MXI2X1 $PINS Y=n3066 S0=FE_OFN187_n4347 B=n4732 A=n886
XU3611 MXI2X1 $PINS Y=n3068 S0=FE_OFN187_n4347 B=n4741 A=n885
XU3612 MXI2X1 $PINS Y=n3070 S0=n4347 B=n4710 A=n884
XU3613 MXI2X1 $PINS Y=n3072 S0=FE_OFN187_n4347 B=n4719 A=n883
XU3614 MXI2X1 $PINS Y=n3074 S0=n111 B=n4692 A=n882
XU3615 MXI2X1 $PINS Y=n3076 S0=n111 B=n4701 A=n881
XU3616 MXI2X1 $PINS Y=n3078 S0=n111 B=n4670 A=n880
XU3617 MXI2X1 $PINS Y=n3080 S0=n111 B=n4679 A=n879
XU3618 MXI2X1 $PINS Y=n3082 S0=n111 B=n4652 A=n878
XU3619 MXI2X1 $PINS Y=n3084 S0=n111 B=n4661 A=n877
XU3620 MXI2X1 $PINS Y=n3086 S0=FE_OFN201_n4349 B=n4952 A=n876
XU3621 MXI2X1 $PINS Y=n3088 S0=FE_OFN201_n4349 B=n4966 A=n875
XU3622 MXI2X1 $PINS Y=n3090 S0=FE_OFN201_n4349 B=n4934 A=n874
XU3623 MXI2X1 $PINS Y=n3092 S0=FE_OFN201_n4349 B=n4943 A=n873
XU3624 MXI2X1 $PINS Y=n3094 S0=FE_OFN201_n4349 B=n4913 A=n872
XU3625 MXI2X1 $PINS Y=n3096 S0=FE_OFN201_n4349 B=n4922 A=n871
XU3626 MXI2X1 $PINS Y=n3098 S0=FE_OFN201_n4349 B=n4895 A=n870
XU3627 MXI2X1 $PINS Y=n3100 S0=FE_OFN201_n4349 B=n4904 A=n869
XU3628 MXI2X1 $PINS Y=n3102 S0=FE_OFN201_n4349 B=n4874 A=n868
XU3629 MXI2X1 $PINS Y=n3104 S0=FE_OFN201_n4349 B=n4883 A=n867
XU3630 MXI2X1 $PINS Y=n3106 S0=FE_OFN201_n4349 B=n4856 A=n866
XU3631 MXI2X1 $PINS Y=n3108 S0=FE_OFN201_n4349 B=n4865 A=n865
XU3632 MXI2X1 $PINS Y=n3110 S0=n4349 B=n4834 A=n864
XU3633 MXI2X1 $PINS Y=n3112 S0=n4349 B=n4843 A=n863
XU3634 MXI2X1 $PINS Y=n3114 S0=n4349 B=n4816 A=n862
XU3635 MXI2X1 $PINS Y=n3116 S0=n4349 B=n4825 A=n861
XU3636 MXI2X1 $PINS Y=n3118 S0=n4349 B=n4790 A=n860
XU3637 MXI2X1 $PINS Y=n3120 S0=n4349 B=n4799 A=n859
XU3638 MXI2X1 $PINS Y=n3122 S0=n4349 B=n4772 A=n858
XU3639 MXI2X1 $PINS Y=n3124 S0=n4349 B=n4781 A=n857
XU3640 MXI2X1 $PINS Y=n3126 S0=n4349 B=n4750 A=n856
XU3641 MXI2X1 $PINS Y=n3128 S0=n4349 B=n4759 A=n855
XU3642 MXI2X1 $PINS Y=n3130 S0=n4349 B=n4732 A=n854
XU3643 MXI2X1 $PINS Y=n3132 S0=n4349 B=n4741 A=n853
XU3644 MXI2X1 $PINS Y=n3134 S0=FE_OFN201_n4349 B=n4710 A=n852
XU3645 MXI2X1 $PINS Y=n3136 S0=n4349 B=n4719 A=n851
XU3646 MXI2X1 $PINS Y=n3138 S0=n121 B=n4692 A=n850
XU3647 MXI2X1 $PINS Y=n3140 S0=n121 B=n4701 A=n849
XU3648 MXI2X1 $PINS Y=n3142 S0=n121 B=n4670 A=n848
XU3649 MXI2X1 $PINS Y=n3144 S0=n121 B=n4679 A=n847
XU3650 MXI2X1 $PINS Y=n3146 S0=n121 B=n4652 A=n846
XU3651 MXI2X1 $PINS Y=n3148 S0=n121 B=n4661 A=n845
XU3652 MXI2X1 $PINS Y=n3150 S0=n4351 B=n4952 A=n844
XU3653 MXI2X1 $PINS Y=n3152 S0=n4351 B=n4966 A=n843
XU3654 MXI2X1 $PINS Y=n3154 S0=n4351 B=n4934 A=n842
XU3655 MXI2X1 $PINS Y=n3156 S0=n4351 B=n4943 A=n841
XU3656 MXI2X1 $PINS Y=n3158 S0=n4351 B=n4913 A=n840
XU3657 MXI2X1 $PINS Y=n3160 S0=n4351 B=n4922 A=n839
XU3658 MXI2X1 $PINS Y=n3162 S0=n4351 B=n4895 A=n838
XU3659 MXI2X1 $PINS Y=n3164 S0=n4351 B=n4904 A=n837
XU3660 MXI2X1 $PINS Y=n3166 S0=n4351 B=n4874 A=n836
XU3661 MXI2X1 $PINS Y=n3168 S0=n4351 B=n4883 A=n835
XU3662 MXI2X1 $PINS Y=n3170 S0=n4351 B=n4856 A=n834
XU3663 MXI2X1 $PINS Y=n3172 S0=n4351 B=n4865 A=n833
XU3664 MXI2X1 $PINS Y=n3174 S0=FE_OFN197_n4351 B=n4834 A=n832
XU3665 MXI2X1 $PINS Y=n3176 S0=FE_OFN197_n4351 B=n4843 A=n831
XU3666 MXI2X1 $PINS Y=n3178 S0=FE_OFN197_n4351 B=n4816 A=n830
XU3667 MXI2X1 $PINS Y=n3180 S0=FE_OFN197_n4351 B=n4825 A=n829
XU3668 MXI2X1 $PINS Y=n3182 S0=FE_OFN197_n4351 B=n4790 A=n828
XU3669 MXI2X1 $PINS Y=n3184 S0=FE_OFN197_n4351 B=n4799 A=n827
XU3670 MXI2X1 $PINS Y=n3186 S0=FE_OFN197_n4351 B=n4772 A=n826
XU3671 MXI2X1 $PINS Y=n3188 S0=FE_OFN197_n4351 B=n4781 A=n825
XU3672 MXI2X1 $PINS Y=n3190 S0=FE_OFN197_n4351 B=n4750 A=n824
XU3673 MXI2X1 $PINS Y=n3192 S0=FE_OFN197_n4351 B=n4759 A=n823
XU3674 MXI2X1 $PINS Y=n3194 S0=FE_OFN197_n4351 B=n4732 A=n822
XU3675 MXI2X1 $PINS Y=n3196 S0=FE_OFN197_n4351 B=n4741 A=n821
XU3676 MXI2X1 $PINS Y=n3198 S0=n4351 B=n4710 A=n820
XU3677 MXI2X1 $PINS Y=n3200 S0=FE_OFN197_n4351 B=n4719 A=n819
XU3678 MXI2X1 $PINS Y=n3202 S0=n140 B=n4692 A=n818
XU3679 MXI2X1 $PINS Y=n3204 S0=n140 B=n4701 A=n817
XU3680 MXI2X1 $PINS Y=n3206 S0=n140 B=n4670 A=n816
XU3681 MXI2X1 $PINS Y=n3208 S0=n140 B=n4679 A=n815
XU3682 MXI2X1 $PINS Y=n3210 S0=n140 B=n4652 A=n814
XU3683 MXI2X1 $PINS Y=n3212 S0=n140 B=n4661 A=n813
XU3684 MXI2X1 $PINS Y=n3214 S0=n131 B=n4399 A=n812
XU3685 MXI2X1 $PINS Y=n3216 S0=n131 B=n4966 A=n811
XU3686 MXI2X1 $PINS Y=n3218 S0=n131 B=n4934 A=n810
XU3687 MXI2X1 $PINS Y=n3220 S0=n131 B=n4943 A=n809
XU3688 MXI2X1 $PINS Y=n3222 S0=n131 B=n4913 A=n808
XU3689 MXI2X1 $PINS Y=n3224 S0=n131 B=n4922 A=n807
XU3690 MXI2X1 $PINS Y=n3226 S0=n131 B=n4895 A=n806
XU3691 MXI2X1 $PINS Y=n3228 S0=n131 B=n4904 A=n805
XU3692 MXI2X1 $PINS Y=n3230 S0=n131 B=n4874 A=n804
XU3693 MXI2X1 $PINS Y=n3232 S0=n131 B=n4883 A=n803
XU3694 MXI2X1 $PINS Y=n3234 S0=n131 B=n4856 A=n802
XU3695 MXI2X1 $PINS Y=n3236 S0=n131 B=n4390 A=n801
XU3696 MXI2X1 $PINS Y=n3238 S0=FE_OFN192_n4353 B=n4834 A=n800
XU3697 MXI2X1 $PINS Y=n3240 S0=FE_OFN192_n4353 B=n4388 A=n799
XU3698 MXI2X1 $PINS Y=n3242 S0=FE_OFN192_n4353 B=n4816 A=n798
XU3699 MXI2X1 $PINS Y=n3244 S0=FE_OFN192_n4353 B=n4825 A=n797
XU3700 MXI2X1 $PINS Y=n3246 S0=FE_OFN192_n4353 B=n4383 A=n796
XU3701 MXI2X1 $PINS Y=n3248 S0=FE_OFN192_n4353 B=n4384 A=n795
XU3702 MXI2X1 $PINS Y=n3250 S0=FE_OFN192_n4353 B=n4381 A=n794
XU3703 MXI2X1 $PINS Y=n3252 S0=FE_OFN192_n4353 B=n4382 A=n793
XU3704 MXI2X1 $PINS Y=n3254 S0=FE_OFN192_n4353 B=n4379 A=n792
XU3705 MXI2X1 $PINS Y=n3256 S0=FE_OFN192_n4353 B=n4380 A=n791
XU3706 MXI2X1 $PINS Y=n3258 S0=FE_OFN192_n4353 B=n4377 A=n790
XU3707 MXI2X1 $PINS Y=n3260 S0=FE_OFN192_n4353 B=n4378 A=n789
XU3708 MXI2X1 $PINS Y=n3262 S0=n131 B=n4710 A=n788
XU3709 MXI2X1 $PINS Y=n3264 S0=n131 B=n4719 A=n787
XU3710 MXI2X1 $PINS Y=n3266 S0=n131 B=n4692 A=n786
XU3711 MXI2X1 $PINS Y=n3268 S0=FE_OFN192_n4353 B=n4374 A=n785
XU3712 MXI2X1 $PINS Y=n3270 S0=FE_OFN192_n4353 B=n4371 A=n784
XU3713 MXI2X1 $PINS Y=n3272 S0=n131 B=n4372 A=n783
XU3714 MXI2X1 $PINS Y=n3274 S0=n131 B=n4369 A=n782
XU3715 MXI2X1 $PINS Y=n3276 S0=n131 B=n4370 A=n781
XU3716 MXI2X1 $PINS Y=n3278 S0=n4355 B=n4952 A=n780
XU3717 MXI2X1 $PINS Y=n3280 S0=n4355 B=n4966 A=n779
XU3718 MXI2X1 $PINS Y=n3282 S0=n4355 B=n4934 A=n778
XU3719 MXI2X1 $PINS Y=n3284 S0=n4355 B=n4943 A=n777
XU3720 MXI2X1 $PINS Y=n3286 S0=n4355 B=n4913 A=n776
XU3721 MXI2X1 $PINS Y=n3288 S0=n4355 B=n4922 A=n775
XU3722 MXI2X1 $PINS Y=n3290 S0=n4355 B=n4895 A=n774
XU3723 MXI2X1 $PINS Y=n3292 S0=n4355 B=n4904 A=n773
XU3724 MXI2X1 $PINS Y=n3294 S0=n4355 B=n4874 A=n772
XU3725 MXI2X1 $PINS Y=n3296 S0=n4355 B=n4883 A=n771
XU3726 MXI2X1 $PINS Y=n3298 S0=n4355 B=n4856 A=n770
XU3727 MXI2X1 $PINS Y=n3300 S0=n4355 B=n4865 A=n769
XU3728 MXI2X1 $PINS Y=n3302 S0=FE_OFN188_n4355 B=n4834 A=n768
XU3729 MXI2X1 $PINS Y=n3304 S0=FE_OFN188_n4355 B=n4843 A=n767
XU3730 MXI2X1 $PINS Y=n3306 S0=FE_OFN188_n4355 B=n4816 A=n766
XU3731 MXI2X1 $PINS Y=n3308 S0=FE_OFN188_n4355 B=n4825 A=n765
XU3732 MXI2X1 $PINS Y=n3310 S0=FE_OFN188_n4355 B=n4790 A=n764
XU3733 MXI2X1 $PINS Y=n3312 S0=FE_OFN188_n4355 B=n4799 A=n763
XU3734 MXI2X1 $PINS Y=n3314 S0=FE_OFN188_n4355 B=n4772 A=n762
XU3735 MXI2X1 $PINS Y=n3316 S0=FE_OFN188_n4355 B=n4781 A=n761
XU3736 MXI2X1 $PINS Y=n3318 S0=FE_OFN188_n4355 B=n4750 A=n760
XU3737 MXI2X1 $PINS Y=n3320 S0=FE_OFN188_n4355 B=n4759 A=n759
XU3738 MXI2X1 $PINS Y=n3322 S0=FE_OFN188_n4355 B=n4732 A=n758
XU3739 MXI2X1 $PINS Y=n3324 S0=FE_OFN188_n4355 B=n4741 A=n757
XU3740 MXI2X1 $PINS Y=n3326 S0=n112 B=n4710 A=n756
XU3741 MXI2X1 $PINS Y=n3328 S0=n112 B=n4719 A=n755
XU3742 MXI2X1 $PINS Y=n3330 S0=n112 B=n4692 A=n754
XU3743 MXI2X1 $PINS Y=n3332 S0=n4355 B=n4374 A=n753
XU3744 MXI2X1 $PINS Y=n3334 S0=FE_OFN188_n4355 B=n4371 A=n752
XU3745 MXI2X1 $PINS Y=n3336 S0=n112 B=n4679 A=n751
XU3746 MXI2X1 $PINS Y=n3338 S0=n112 B=n4652 A=n750
XU3747 MXI2X1 $PINS Y=n3340 S0=n112 B=n4661 A=n749
XU3748 MXI2X1 $PINS Y=n3342 S0=n4357 B=n4952 A=n748
XU3749 MXI2X1 $PINS Y=n3344 S0=n4357 B=n4966 A=n747
XU3750 MXI2X1 $PINS Y=n3346 S0=n4357 B=n4934 A=n746
XU3751 MXI2X1 $PINS Y=n3348 S0=n4357 B=n4943 A=SPCASCAN_N28
XU3752 MXI2X1 $PINS Y=n3350 S0=n4357 B=n4913 A=n744
XU3753 MXI2X1 $PINS Y=n3352 S0=n4357 B=n4922 A=n743
XU3754 MXI2X1 $PINS Y=n3354 S0=n4357 B=n4895 A=n742
XU3755 MXI2X1 $PINS Y=n3356 S0=n4357 B=n4904 A=n741
XU3756 MXI2X1 $PINS Y=n3358 S0=n4357 B=n4874 A=n740
XU3757 MXI2X1 $PINS Y=n3360 S0=n4357 B=n4883 A=n739
XU3758 MXI2X1 $PINS Y=n3362 S0=n4357 B=n4856 A=n738
XU3759 MXI2X1 $PINS Y=n3364 S0=n4357 B=n4865 A=n737
XU3760 MXI2X1 $PINS Y=n3366 S0=FE_OFN202_n4357 B=n4834 A=n736
XU3761 MXI2X1 $PINS Y=n3368 S0=FE_OFN202_n4357 B=n4843 A=n735
XU3762 MXI2X1 $PINS Y=n3370 S0=FE_OFN202_n4357 B=n4816 A=n734
XU3763 MXI2X1 $PINS Y=n3372 S0=FE_OFN202_n4357 B=n4825 A=n733
XU3764 MXI2X1 $PINS Y=n3374 S0=FE_OFN202_n4357 B=n4790 A=n732
XU3765 MXI2X1 $PINS Y=n3376 S0=FE_OFN202_n4357 B=n4799 A=n731
XU3766 MXI2X1 $PINS Y=n3378 S0=FE_OFN202_n4357 B=n4772 A=n730
XU3767 MXI2X1 $PINS Y=n3380 S0=FE_OFN202_n4357 B=n4781 A=n729
XU3768 MXI2X1 $PINS Y=n3382 S0=FE_OFN202_n4357 B=n4750 A=n728
XU3769 MXI2X1 $PINS Y=n3384 S0=FE_OFN202_n4357 B=n4759 A=n727
XU3770 MXI2X1 $PINS Y=n3386 S0=FE_OFN202_n4357 B=n4732 A=n726
XU3771 MXI2X1 $PINS Y=n3388 S0=FE_OFN202_n4357 B=n4741 A=n725
XU3772 MXI2X1 $PINS Y=n3390 S0=n4357 B=n4710 A=n724
XU3773 MXI2X1 $PINS Y=n3392 S0=FE_OFN202_n4357 B=n4719 A=n723
XU3774 MXI2X1 $PINS Y=n3394 S0=n122 B=n4692 A=n722
XU3775 MXI2X1 $PINS Y=n3396 S0=n122 B=n4701 A=n721
XU3776 MXI2X1 $PINS Y=n3398 S0=n122 B=n4670 A=n720
XU3777 MXI2X1 $PINS Y=n3400 S0=n122 B=n4679 A=n719
XU3778 MXI2X1 $PINS Y=n3402 S0=n122 B=n4652 A=n718
XU3779 MXI2X1 $PINS Y=n3404 S0=n122 B=n4661 A=n717
XU3780 MXI2X1 $PINS Y=n3406 S0=n4359 B=n4952 A=n716
XU3781 MXI2X1 $PINS Y=n3408 S0=n4359 B=n4966 A=n715
XU3782 MXI2X1 $PINS Y=n3410 S0=n4359 B=n4934 A=n714
XU3783 MXI2X1 $PINS Y=n3412 S0=n4359 B=n4943 A=n713
XU3784 MXI2X1 $PINS Y=n3414 S0=n4359 B=n4913 A=n712
XU3785 MXI2X1 $PINS Y=n3416 S0=n4359 B=n4922 A=n711
XU3786 MXI2X1 $PINS Y=n3418 S0=n4359 B=n4895 A=n710
XU3787 MXI2X1 $PINS Y=n3420 S0=n4359 B=n4904 A=n709
XU3788 MXI2X1 $PINS Y=n3422 S0=n4359 B=n4874 A=n708
XU3789 MXI2X1 $PINS Y=n3424 S0=n4359 B=n4883 A=n707
XU3790 MXI2X1 $PINS Y=n3426 S0=n4359 B=n4856 A=n706
XU3791 MXI2X1 $PINS Y=n3428 S0=n4359 B=n4865 A=n705
XU3792 MXI2X1 $PINS Y=n3430 S0=FE_OFN194_n4359 B=n4834 A=n704
XU3793 MXI2X1 $PINS Y=n3432 S0=FE_OFN194_n4359 B=n4843 A=n703
XU3794 MXI2X1 $PINS Y=n3434 S0=FE_OFN194_n4359 B=n4816 A=n702
XU3795 MXI2X1 $PINS Y=n3436 S0=FE_OFN194_n4359 B=n4825 A=n701
XU3796 MXI2X1 $PINS Y=n3438 S0=FE_OFN194_n4359 B=n4790 A=n700
XU3797 MXI2X1 $PINS Y=n3440 S0=FE_OFN194_n4359 B=n4799 A=n699
XU3798 MXI2X1 $PINS Y=n3442 S0=FE_OFN194_n4359 B=n4772 A=n698
XU3799 MXI2X1 $PINS Y=n3444 S0=FE_OFN194_n4359 B=n4781 A=n697
XU3800 MXI2X1 $PINS Y=n3446 S0=FE_OFN194_n4359 B=n4750 A=n696
XU3801 MXI2X1 $PINS Y=n3448 S0=FE_OFN194_n4359 B=n4759 A=n695
XU3802 MXI2X1 $PINS Y=n3450 S0=FE_OFN194_n4359 B=n4732 A=n694
XU3803 MXI2X1 $PINS Y=n3452 S0=FE_OFN194_n4359 B=n4741 A=n693
XU3804 MXI2X1 $PINS Y=n3454 S0=n4359 B=n4710 A=n692
XU3805 MXI2X1 $PINS Y=n3456 S0=FE_OFN194_n4359 B=n4719 A=n691
XU3806 MXI2X1 $PINS Y=n3458 S0=n123 B=n4692 A=n690
XU3807 MXI2X1 $PINS Y=n3460 S0=n123 B=n4701 A=n689
XU3808 MXI2X1 $PINS Y=n3462 S0=n123 B=n4670 A=n688
XU3809 MXI2X1 $PINS Y=n3464 S0=n123 B=n4679 A=n687
XU3810 MXI2X1 $PINS Y=n3466 S0=n123 B=n4652 A=n686
XU3811 MXI2X1 $PINS Y=n3468 S0=n123 B=n4661 A=n685
XU3812 MXI2X1 $PINS Y=n3470 S0=n4361 B=n4952 A=n684
XU3813 MXI2X1 $PINS Y=n3472 S0=n4361 B=n4966 A=n683
XU3814 MXI2X1 $PINS Y=n3474 S0=n4361 B=n4934 A=n682
XU3815 MXI2X1 $PINS Y=n3476 S0=n4361 B=n4943 A=n681
XU3816 MXI2X1 $PINS Y=n3478 S0=n4361 B=n4913 A=n680
XU3817 MXI2X1 $PINS Y=n3480 S0=n4361 B=n4922 A=n679
XU3818 MXI2X1 $PINS Y=n3482 S0=n4361 B=n4895 A=n678
XU3819 MXI2X1 $PINS Y=n3484 S0=n4361 B=n4904 A=n677
XU3820 MXI2X1 $PINS Y=n3486 S0=n4361 B=n4874 A=n676
XU3821 MXI2X1 $PINS Y=n3488 S0=n4361 B=n4883 A=n675
XU3822 MXI2X1 $PINS Y=n3490 S0=n4361 B=n4856 A=n674
XU3823 MXI2X1 $PINS Y=n3492 S0=n4361 B=n4865 A=n673
XU3824 MXI2X1 $PINS Y=n3494 S0=FE_OFN189_n4361 B=n4834 A=n672
XU3825 MXI2X1 $PINS Y=n3496 S0=FE_OFN189_n4361 B=n4843 A=n671
XU3826 MXI2X1 $PINS Y=n3498 S0=FE_OFN189_n4361 B=n4816 A=n670
XU3827 MXI2X1 $PINS Y=n3500 S0=FE_OFN189_n4361 B=n4825 A=n669
XU3828 MXI2X1 $PINS Y=n3502 S0=FE_OFN189_n4361 B=n4790 A=n668
XU3829 MXI2X1 $PINS Y=n3504 S0=FE_OFN189_n4361 B=n4799 A=n667
XU3830 MXI2X1 $PINS Y=n3506 S0=FE_OFN189_n4361 B=n4772 A=n666
XU3831 MXI2X1 $PINS Y=n3508 S0=FE_OFN189_n4361 B=n4781 A=n665
XU3832 MXI2X1 $PINS Y=n3510 S0=FE_OFN189_n4361 B=n4750 A=n664
XU3833 MXI2X1 $PINS Y=n3512 S0=FE_OFN189_n4361 B=n4759 A=n663
XU3834 MXI2X1 $PINS Y=n3514 S0=FE_OFN189_n4361 B=n4732 A=n662
XU3835 MXI2X1 $PINS Y=n3516 S0=FE_OFN189_n4361 B=n4741 A=n661
XU3836 MXI2X1 $PINS Y=n3518 S0=n4361 B=n4710 A=n660
XU3837 MXI2X1 $PINS Y=n3520 S0=FE_OFN189_n4361 B=n4719 A=n659
XU3838 MXI2X1 $PINS Y=n3522 S0=n125 B=n4692 A=n658
XU3839 MXI2X1 $PINS Y=n3524 S0=n125 B=n4701 A=n657
XU3840 MXI2X1 $PINS Y=n3526 S0=n125 B=n4670 A=n656
XU3841 MXI2X1 $PINS Y=n3528 S0=n125 B=n4679 A=n655
XU3842 MXI2X1 $PINS Y=n3530 S0=n125 B=n4652 A=n654
XU3843 MXI2X1 $PINS Y=n3532 S0=n125 B=n4661 A=n653
XU3844 CLKMX2X2 $PINS Y=n1734 S0=n114 B=WriteData[28] A=n4570
XU3845 CLKMX2X2 $PINS Y=n1736 S0=n114 B=WriteData[29] A=n4571
XU3846 INVXL $PINS Y=n4780 A=MEM_RegWriteData[19]
XU3847 INVXL $PINS Y=n4798 A=MEM_RegWriteData[17]
XU3848 INVXL $PINS Y=n4789 A=MEM_RegWriteData[16]
XU3849 INVXL $PINS Y=n4771 A=MEM_RegWriteData[18]
XU3850 INVXL $PINS Y=n4758 A=MEM_RegWriteData[21]
XU3851 INVXL $PINS Y=n4749 A=MEM_RegWriteData[20]
XU3852 INVXL $PINS Y=n4740 A=MEM_RegWriteData[23]
XU3853 INVXL $PINS Y=n4731 A=MEM_RegWriteData[22]
XU3854 INVXL $PINS Y=n4718 A=MEM_RegWriteData[25]
XU3855 INVXL $PINS Y=n4709 A=MEM_RegWriteData[24]
XU3856 INVXL $PINS Y=n4700 A=MEM_RegWriteData[27]
XU3857 INVXL $PINS Y=n4691 A=MEM_RegWriteData[26]
XU3858 INVXL $PINS Y=n4678 A=MEM_RegWriteData[29]
XU3859 INVXL $PINS Y=n4669 A=MEM_RegWriteData[28]
XU3860 INVXL $PINS Y=n4660 A=MEM_RegWriteData[31]
XU3861 INVXL $PINS Y=n4651 A=MEM_RegWriteData[30]
XU3862 INVXL $PINS Y=n4964 A=MEM_RegWriteData[1]
XU3863 INVXL $PINS Y=n4951 A=MEM_RegWriteData[0]
XU3864 INVXL $PINS Y=n4942 A=MEM_RegWriteData[3]
XU3865 INVXL $PINS Y=n4933 A=MEM_RegWriteData[2]
XU3866 INVXL $PINS Y=n4921 A=MEM_RegWriteData[5]
XU3867 INVXL $PINS Y=n4912 A=MEM_RegWriteData[4]
XU3868 INVXL $PINS Y=n4903 A=MEM_RegWriteData[7]
XU3869 INVXL $PINS Y=n4894 A=MEM_RegWriteData[6]
XU3870 INVXL $PINS Y=n4882 A=MEM_RegWriteData[9]
XU3871 INVXL $PINS Y=n4873 A=MEM_RegWriteData[8]
XU3872 INVXL $PINS Y=n4864 A=MEM_RegWriteData[11]
XU3873 INVXL $PINS Y=n4855 A=MEM_RegWriteData[10]
XU3874 INVXL $PINS Y=n4842 A=MEM_RegWriteData[13]
XU3875 INVXL $PINS Y=n4833 A=MEM_RegWriteData[12]
XU3876 INVXL $PINS Y=n4824 A=MEM_RegWriteData[15]
XU3877 INVXL $PINS Y=n4815 A=MEM_RegWriteData[14]
XU3878 NAND2X1 $PINS Y=n12 B=n4443 A=Instruction[15]
XU3879 MXI2X1 $PINS Y=n141 S0=n4437 B=n601 A=FE_PT1_n337
XU3880 MXI2X1 $PINS Y=n142 S0=n4437 B=n612 A=FE_PT1_n336
XU3881 MXI2X1 $PINS Y=n144 S0=n4438 B=n624 A=n4997
XU3882 MXI2X1 $PINS Y=n145 S0=n4437 B=SPCASCAN_N15 A=n4996
XU3883 MXI2X1 $PINS Y=n146 S0=n4437 B=n626 A=n4995
XU3884 MXI2X1 $PINS Y=n148 S0=n4437 B=n604 A=n4992
XU3885 MXI2X1 $PINS Y=n152 S0=n4437 B=SPCASCAN_N17 A=n4994
XU3886 MXI2X1 $PINS Y=n153 S0=n4437 B=n603 A=n4993
XU3887 MXI2X1 $PINS Y=n154 S0=n4437 B=n605 A=n4991
XU3888 MXI2X1 $PINS Y=n155 S0=n4437 B=n606 A=n4990
XU3889 OAI31XL $PINS Y=n172 B0=n181 A2=n180 A1=n179 A0=n178
XU3890 NAND4X1 $PINS Y=n178 D=n187 C=n186 B=n185 A=n184
XU3891 NAND4BBXL $PINS Y=n179 D=n183 C=FE_PT1_n336 BN=Instruction[26]
+ AN=Instruction[15]
XU3892 NAND4X1 $PINS Y=n180 D=n182 C=n170 B=n4994 A=FE_PT1_n337
XU3893 OAI22XL $PINS Y=n3606 B1=n4986 B0=n172 A1=n4443 A0=n638
XU3894 OAI22XL $PINS Y=n3608 B1=n4988 B0=n172 A1=n4443 A0=n640
XU3895 OAI22XL $PINS Y=n3610 B1=n4987 B0=n172 A1=n4443 A0=n641
XU3896 NOR2BX1 $PINS Y=n133 B=n4437 AN=n168
XU3897 OAI31XL $PINS Y=n168 B0=n167 A2=MEM_RegWrite A1=SPCASCAN_N2 A0=n169
XU3898 OAI22XL $PINS Y=n3611 B1=n177 B0=n176 A1=n4448 A0=n642
XU3899 NAND4X1 $PINS Y=n176 D=n4995 C=n4996 B=n4997 A=n4988
XU3900 NAND3X1 $PINS Y=n177 C=ALUOp[1] B=n4986 A=n4985
XU3901 CLKINVX1 $PINS Y=n4997 A=Instruction[3]
XU3902 CLKINVX1 $PINS Y=n4990 A=Instruction[14]
XU3903 CLKINVX1 $PINS Y=n4991 A=Instruction[13]
XU3904 CLKINVX1 $PINS Y=n4996 A=Instruction[4]
XU3905 CLKINVX1 $PINS Y=n4995 A=Instruction[5]
XU3906 CLKINVX1 $PINS Y=n4992 A=Instruction[12]
XU3907 CLKINVX1 $PINS Y=n4993 A=Instruction[11]
XU3909 CLKINVX1 $PINS Y=n4994 A=Instruction[10]
XU3911 OAI2BB2XL $PINS Y=n3607 B1=n4443 B0=n639 A1N=ALUOp[1] A0N=n4985
XU3912 OAI21XL $PINS Y=n3570 B0=n4302 A1=n4448 A0=n636
XU3913 OAI21XL $PINS Y=n3571 B0=n4302 A1=FE_OFN125_n4445 A0=SPCASCAN_N22
XU3914 AO22X1 $PINS Y=n3609 B1=n4985 B0=RegDst A1=EX[4] A0=n4441
XU3915 AO22X1 $PINS Y=n3572 B1=n4363 B0=PCadd4[16] A1=n1 A0=n4640
XU3916 AO22X1 $PINS Y=n3573 B1=n4363 B0=PCadd4[17] A1=n2 A0=n4640
XU3917 AO22X1 $PINS Y=n3574 B1=n4363 B0=PCadd4[18] A1=n3 A0=n4640
XU3918 AO22X1 $PINS Y=n3575 B1=n4363 B0=PCadd4[19] A1=SPCASCAN_N12 A0=n4640
XU3919 AO22X1 $PINS Y=n3576 B1=n4363 B0=PCadd4[20] A1=n5 A0=n4640
XU3920 AO22X1 $PINS Y=n3577 B1=n4363 B0=PCadd4[21] A1=n6 A0=n4640
XU3921 AO22X1 $PINS Y=n3578 B1=n4363 B0=PCadd4[22] A1=n7 A0=n4640
XU3922 AO22X1 $PINS Y=n3579 B1=n4363 B0=PCadd4[23] A1=n8 A0=n4640
XU3923 AO22X1 $PINS Y=n3580 B1=n4363 B0=PCadd4[24] A1=n9 A0=n4364
XU3924 AO22X1 $PINS Y=n3581 B1=n4363 B0=PCadd4[25] A1=n11 A0=n4364
XU3925 AO22X1 $PINS Y=n3582 B1=n4638 B0=PCadd4[26] A1=n13 A0=n4364
XU3926 AO22X1 $PINS Y=n3583 B1=n4638 B0=PCadd4[27] A1=SPCASCAN_N7 A0=n4364
XU3927 AO22X1 $PINS Y=n3584 B1=n4638 B0=PCadd4[28] A1=n15 A0=n4364
XU3928 AO22X1 $PINS Y=n3585 B1=n4638 B0=PCadd4[29] A1=n16 A0=n4364
XU3929 AO22X1 $PINS Y=n3586 B1=n4638 B0=PCadd4[30] A1=n17 A0=n4364
XU3930 AO22X1 $PINS Y=n3587 B1=n4638 B0=PCadd4[31] A1=n4639 A0=n4364
XU3931 AO22X1 $PINS Y=n3590 B1=n4638 B0=PCadd4[2] A1=SPCASCAN_N23 A0=n4364
XU3932 AO22X1 $PINS Y=n3591 B1=n4638 B0=PCadd4[3] A1=n19 A0=n4364
XU3933 AO22X1 $PINS Y=n3592 B1=n4638 B0=PCadd4[4] A1=SPCASCAN_N26 A0=n4364
XU3934 AO22X1 $PINS Y=n3593 B1=n4638 B0=PCadd4[5] A1=SPCASCAN_N25 A0=n4364
XU3935 AO22X1 $PINS Y=n3594 B1=n4638 B0=PCadd4[6] A1=n22 A0=n4364
XU3936 AO22X1 $PINS Y=n3595 B1=n4638 B0=PCadd4[7] A1=SPCBSCAN_N40 A0=n4364
XU3937 AO22X1 $PINS Y=n3596 B1=n4638 B0=PCadd4[8] A1=n24 A0=n4640
XU3938 AO22X1 $PINS Y=n3597 B1=n4638 B0=PCadd4[9] A1=SPCASCAN_N29 A0=n4640
XU3939 AO22X1 $PINS Y=n3598 B1=n4638 B0=PCadd4[10] A1=n26 A0=n4640
XU3940 AO22X1 $PINS Y=n3599 B1=n4638 B0=PCadd4[11] A1=n27 A0=n4640
XU3941 AO22X1 $PINS Y=n3600 B1=n4363 B0=PCadd4[12] A1=n28 A0=n4640
XU3942 AO22X1 $PINS Y=n3601 B1=n4363 B0=PCadd4[13] A1=n29 A0=n4640
XU3943 AO22X1 $PINS Y=n3602 B1=n4363 B0=PCadd4[14] A1=n30 A0=n4640
XU3944 AO22X1 $PINS Y=n3603 B1=n4363 B0=PCadd4[15] A1=n31 A0=n4640
XU3945 AO22X1 $PINS Y=n3605 B1=n4985 B0=ALUSrc A1=EX[0] A0=n4441
XU3946 AO22X1 $PINS Y=n3612 B1=n4985 B0=MemWrite A1=MEM[0] A0=n4441
XU3947 AO22X1 $PINS Y=n3613 B1=n4985 B0=MemRead A1=MEM[1] A0=n4441
XU3948 AO22X1 $PINS Y=n3614 B1=n4985 B0=MemtoReg A1=WB[0] A0=n4441
XU3949 AO22X1 $PINS Y=n3615 B1=n4985 B0=RegWrite A1=WB[1] A0=n4441
XU3950 AO22X1 $PINS Y=n3588 B1=n4638 B0=PCadd4[0] A1=n32 A0=n4640
XU3951 AO22X1 $PINS Y=n3589 B1=n4638 B0=PCadd4[1] A1=SPCASCAN_N27 A0=n4640
XU3952 NOR4X1 $PINS Y=n182 D=Instruction[11] C=Instruction[12]
+ B=Instruction[13] A=Instruction[14]
XU3953 OAI22XL $PINS Y=n3567 B1=n4991 B0=n4437 A1=FE_OFN125_n4445 A0=n633
XU3954 OAI22XL $PINS Y=n3568 B1=n4990 B0=n4438 A1=n4443 A0=n634
XU3955 OAI22XL $PINS Y=n3565 B1=n4993 B0=n4437 A1=n4443 A0=n631
XU3956 OAI22XL $PINS Y=n3566 B1=n4992 B0=n4438 A1=n4448 A0=n632
XU3957 NOR3X1 $PINS Y=n184 C=Instruction[6] B=Instruction[7] A=Instruction[5]
XU3958 MXI2X1 $PINS Y=n3616 S0=n4438 B=n643 A=n4423
XU3959 MXI2X1 $PINS Y=n3617 S0=n4438 B=n644 A=n4424
XU3960 MXI2X1 $PINS Y=n3618 S0=n4438 B=SPCASCAN_N19 A=n4425
XU3961 MXI2X1 $PINS Y=n3619 S0=FE_OFN124_n4438 B=n646 A=n4427
XU3962 MXI2X1 $PINS Y=n3620 S0=FE_OFN124_n4438 B=n647 A=n4428
XU3963 MXI2X1 $PINS Y=n3621 S0=FE_OFN124_n4438 B=n648 A=n4430
XU3964 MXI2X1 $PINS Y=n3622 S0=n4438 B=n649 A=n4431
XU3965 MXI2X1 $PINS Y=n3623 S0=n4438 B=n650 A=n4432
XU3966 MXI2X1 $PINS Y=n3624 S0=n4438 B=n651 A=n4434
XU3967 MXI2X1 $PINS Y=n3625 S0=n4438 B=n652 A=n4435
XU3968 OAI21XL $PINS Y=n3604 B0=n134 A1=n133 A0=n1899
XU3969 OAI21XL $PINS Y=n3569 B0=n12 A1=n4448 A0=n635
XU3970 CLKINVX3 $PINS Y=n4952 A=WriteData[0]
XU3971 CLKINVX3 $PINS Y=n4966 A=WriteData[1]
XU3972 CLKINVX3 $PINS Y=n4934 A=WriteData[2]
XU3973 CLKINVX3 $PINS Y=n4943 A=WriteData[3]
XU3974 CLKINVX3 $PINS Y=n4913 A=WriteData[4]
XU3975 CLKINVX3 $PINS Y=n4922 A=WriteData[5]
XU3976 CLKINVX3 $PINS Y=n4895 A=WriteData[6]
XU3977 CLKINVX3 $PINS Y=n4904 A=WriteData[7]
XU3978 CLKINVX3 $PINS Y=n4874 A=WriteData[8]
XU3979 CLKINVX3 $PINS Y=n4883 A=WriteData[9]
XU3980 CLKINVX3 $PINS Y=n4856 A=WriteData[10]
XU3981 CLKINVX3 $PINS Y=n4865 A=WriteData[11]
XU3982 CLKINVX3 $PINS Y=n4834 A=WriteData[12]
XU3983 CLKINVX3 $PINS Y=n4843 A=WriteData[13]
XU3984 CLKINVX3 $PINS Y=n4816 A=WriteData[14]
XU3985 CLKINVX3 $PINS Y=n4825 A=WriteData[15]
XU3986 CLKINVX3 $PINS Y=n4790 A=WriteData[16]
XU3987 CLKINVX3 $PINS Y=n4799 A=WriteData[17]
XU3988 CLKINVX3 $PINS Y=n4772 A=WriteData[18]
XU3989 CLKINVX3 $PINS Y=n4781 A=WriteData[19]
XU3990 CLKINVX3 $PINS Y=n4750 A=WriteData[20]
XU3991 CLKINVX3 $PINS Y=n4759 A=WriteData[21]
XU3992 CLKINVX3 $PINS Y=n4732 A=WriteData[22]
XU3993 CLKINVX3 $PINS Y=n4741 A=WriteData[23]
XU3994 CLKINVX3 $PINS Y=n4710 A=WriteData[24]
XU3995 CLKINVX3 $PINS Y=n4719 A=WriteData[25]
XU3996 CLKINVX3 $PINS Y=n4692 A=WriteData[26]
XU3997 CLKINVX3 $PINS Y=n4701 A=WriteData[27]
XU3998 CLKINVX3 $PINS Y=n4670 A=WriteData[28]
XU3999 CLKINVX3 $PINS Y=n4679 A=WriteData[29]
XU4000 CLKINVX3 $PINS Y=n4652 A=WriteData[30]
XU4001 CLKINVX3 $PINS Y=n4661 A=WriteData[31]
XU4002 CLKINVX1 $PINS Y=n4574 A=n124
XU4003 CLKINVX3 $PINS Y=n4640 A=n133
XU4004 CLKINVX1 $PINS Y=n4638 A=n134
Xmult_add_145_aco InstructionDecode_DW_mult_uns_1 $PINS
+ a[31]=next_Immediate_SE[29] a[30]=next_Immediate_SE[28]
+ a[29]=next_Immediate_SE[27] a[28]=next_Immediate_SE[26]
+ a[27]=next_Immediate_SE[25] a[26]=next_Immediate_SE[24]
+ a[25]=next_Immediate_SE[23] a[24]=next_Immediate_SE[22]
+ a[23]=next_Immediate_SE[21] a[22]=next_Immediate_SE[20]
+ a[21]=next_Immediate_SE[19] a[20]=next_Immediate_SE[18]
+ a[19]=next_Immediate_SE[17] a[18]=next_Immediate_SE[16]
+ a[17]=next_Immediate_SE[15] a[16]=n155 a[15]=n154 a[14]=n148 a[13]=n153
+ a[12]=n152 a[11]=n151 a[10]=n147 a[9]=n150 a[8]=n149 a[7]=n146 a[6]=n145
+ a[5]=n144 a[4]=n143 a[3]=n142 a[2]=n141 a[1]=VSS a[0]=VSS b=n1795
+ product[32]=SYNOPSYS_UNCONNECTED__0 product[31]=N484 product[30]=N483
+ product[29]=N482 product[28]=N481 product[27]=N480 product[26]=N479
+ product[25]=N478 product[24]=N477 product[23]=N476 product[22]=N475
+ product[21]=N474 product[20]=N473 product[19]=N472 product[18]=N471
+ product[17]=N470 product[16]=N469 product[15]=N468 product[14]=N467
+ product[13]=N466 product[12]=N465 product[11]=N464 product[10]=N463
+ product[9]=N462 product[8]=N461 product[7]=N460 product[6]=N459 product[5]=N458
+ product[4]=N457 product[3]=N456 product[2]=N455
+ product[1]=SYNOPSYS_UNCONNECTED__1 product[0]=SYNOPSYS_UNCONNECTED__2
Xadd_145_aco InstructionDecode_DW01_add_2 $PINS A[31]=PCadd4[31]
+ A[30]=PCadd4[30] A[29]=PCadd4[29] A[28]=PCadd4[28] A[27]=PCadd4[27]
+ A[26]=PCadd4[26] A[25]=PCadd4[25] A[24]=PCadd4[24] A[23]=PCadd4[23]
+ A[22]=PCadd4[22] A[21]=PCadd4[21] A[20]=PCadd4[20] A[19]=PCadd4[19]
+ A[18]=PCadd4[18] A[17]=PCadd4[17] A[16]=PCadd4[16] A[15]=PCadd4[15]
+ A[14]=PCadd4[14] A[13]=PCadd4[13] A[12]=PCadd4[12] A[11]=PCadd4[11]
+ A[10]=PCadd4[10] A[9]=PCadd4[9] A[8]=PCadd4[8] A[7]=PCadd4[7] A[6]=PCadd4[6]
+ A[5]=PCadd4[5] A[4]=PCadd4[4] A[3]=PCadd4[3] A[2]=PCadd4[2] A[1]=PCadd4[1]
+ A[0]=PCadd4[0] B[31]=N484 B[30]=N483 B[29]=N482 B[28]=N481 B[27]=N480
+ B[26]=N479 B[25]=N478 B[24]=N477 B[23]=N476 B[22]=N475 B[21]=N474 B[20]=N473
+ B[19]=N472 B[18]=N471 B[17]=N470 B[16]=N469 B[15]=N468 B[14]=N467 B[13]=N466
+ B[12]=N465 B[11]=N464 B[10]=N463 B[9]=N462 B[8]=N461 B[7]=N460 B[6]=N459
+ B[5]=N458 B[4]=N457 B[3]=N456 B[2]=N455 B[1]=VSS B[0]=VSS CI=VSS
+ SUM[31]=PCbranched[31] SUM[30]=PCbranched[30] SUM[29]=PCbranched[29]
+ SUM[28]=PCbranched[28] SUM[27]=PCbranched[27] SUM[26]=PCbranched[26]
+ SUM[25]=PCbranched[25] SUM[24]=PCbranched[24] SUM[23]=PCbranched[23]
+ SUM[22]=PCbranched[22] SUM[21]=PCbranched[21] SUM[20]=PCbranched[20]
+ SUM[19]=PCbranched[19] SUM[18]=PCbranched[18] SUM[17]=PCbranched[17]
+ SUM[16]=PCbranched[16] SUM[15]=PCbranched[15] SUM[14]=PCbranched[14]
+ SUM[13]=PCbranched[13] SUM[12]=PCbranched[12] SUM[11]=PCbranched[11]
+ SUM[10]=PCbranched[10] SUM[9]=PCbranched[9] SUM[8]=PCbranched[8]
+ SUM[7]=PCbranched[7] SUM[6]=PCbranched[6] SUM[5]=PCbranched[5]
+ SUM[4]=PCbranched[4] SUM[3]=PCbranched[3] SUM[2]=PCbranched[2]
+ SUM[1]=PCbranched[1] SUM[0]=PCbranched[0] n4586=n4586
XEX_reg[6] SDFFRXL $PINS SI=n1743 SE=FE_OFN105_test_se_i RN=n4462 QN=n642
+ Q=EX[6] D=n3611 CK=clk_i__L3_N24
XEX_reg[5] SDFFRXL $PINS SI=EX[6] SE=FE_OFN105_test_se_i RN=n4462 QN=n641
+ Q=EX[5] D=n3610 CK=clk_i__L3_N24
XWB_reg[0] SDFFRXL $PINS SI=n1751 SE=FE_OFN109_test_se_i RN=FE_OFN148_n4462
+ QN=n1753 Q=WB[0] D=n3614 CK=clk_i__L3_N9
XMEM_reg[0] SDFFRXL $PINS SI=n638 SE=FE_OFN23_test_se_i RN=n4462 QN=n1751
+ Q=MEM[0] D=n3612 CK=clk_i__L3_N9
XWB_reg[1] SDFFRXL $PINS SI=n639 SE=FE_OFN23_test_se_i RN=FE_OFN148_n4462
+ QN=test_so2 Q=WB[1] D=n3615 CK=clk_i__L3_N9
XRegisterRd_reg[4] SDFFRXL $PINS SI=n644 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n635 Q=RegisterRd[4] D=n3569 CK=clk_i__L3_N9
XRegisterRd_reg[1] SDFFRXL $PINS SI=n649 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n632 Q=RegisterRd[1] D=n3566 CK=clk_i__L3_N9
XRegisterRd_reg[3] SDFFRXL $PINS SI=n633 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n634 Q=RegisterRd[3] D=n3568 CK=clk_i__L3_N9
XRegisterRd_reg[2] SDFFRXL $PINS SI=n646 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n633 Q=RegisterRd[2] D=n3567 CK=clk_i__L3_N9
XRegisterRd_reg[0] SDFFRXL $PINS SI=n1753 SE=FE_OFN110_test_se_i RN=n4462
+ QN=n631 Q=RegisterRd[0] D=n3565 CK=clk_i__L3_N9
XImmediate_SE_reg[31] SDFFRXL $PINS SI=n615 SE=FE_OFN97_test_se_i RN=n4459
+ QN=SPCASCAN_N22 Q=Immediate_SE[31] D=n3571 CK=clk_i__L3_N11
XImmediate_SE_reg[30] SDFFRXL $PINS SI=n620 SE=FE_OFN97_test_se_i RN=n4459
+ QN=n636 Q=Immediate_SE[30] D=n3570 CK=clk_i__L3_N9
XImmediate_SE_reg[29] SDFFRXL $PINS SI=n636 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n622 Q=Immediate_SE[29] D=next_Immediate_SE[29] CK=clk_i__L3_N9
XImmediate_SE_reg[28] SDFFRXL $PINS SI=n618 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n621 Q=Immediate_SE[28] D=next_Immediate_SE[28] CK=clk_i__L3_N9
XImmediate_SE_reg[27] SDFFRXL $PINS SI=n621 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n620 Q=Immediate_SE[27] D=next_Immediate_SE[27] CK=clk_i__L3_N9
XImmediate_SE_reg[26] SDFFRXL $PINS SI=n622 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n619 Q=Immediate_SE[26] D=next_Immediate_SE[26] CK=clk_i__L3_N9
XImmediate_SE_reg[23] SDFFRXL $PINS SI=n619 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n616 Q=Immediate_SE[23] D=next_Immediate_SE[23] CK=clk_i__L3_N9
XImmediate_SE_reg[22] SDFFRXL $PINS SI=n616 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n615 Q=Immediate_SE[22] D=next_Immediate_SE[22] CK=clk_i__L3_N9
XImmediate_SE_reg[21] SDFFRXL $PINS SI=n613 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n614 Q=Immediate_SE[21] D=next_Immediate_SE[21] CK=clk_i__L3_N9
XImmediate_SE_reg[19] SDFFRXL $PINS SI=n617 SE=FE_OFN96_test_se_i RN=n4460
+ QN=n611 Q=Immediate_SE[19] D=next_Immediate_SE[19] CK=clk_i__L3_N11
XImmediate_SE_reg[18] SDFFRXL $PINS SI=n614 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n610 Q=Immediate_SE[18] D=next_Immediate_SE[18] CK=clk_i__L3_N9
XImmediate_SE_reg[17] SDFFRXL $PINS SI=n67 SE=FE_OFN96_test_se_i RN=n4461
+ QN=n609 Q=Immediate_SE[17] D=next_Immediate_SE[17] CK=clk_i__L3_N10
XImmediate_SE_reg[16] SDFFRXL $PINS SI=n609 SE=FE_OFN96_test_se_i RN=n4461
+ QN=n608 Q=Immediate_SE[16] D=next_Immediate_SE[16] CK=clk_i__L3_N10
XImmediate_SE_reg[12] SDFFRXL $PINS SI=n606 SE=FE_OFN110_test_se_i RN=n4461
+ QN=n604 Q=Immediate_SE[12] D=n148 CK=clk_i__L3_N9
XEX_reg[3] SDFFRXL $PINS SI=n635 SE=FE_OFN109_test_se_i RN=n4462 QN=n640
+ Q=EX[3] D=n3608 CK=clk_i__L3_N9
XPCBuffer_reg[15] SDFFRXL $PINS SI=n8 SE=FE_OFN99_test_se_i RN=FE_OFN163_n4451
+ QN=n3642 Q=n31 D=n3603 CK=clk_i__L3_N13
XPCBuffer_reg[14] SDFFRXL $PINS SI=n659 SE=FE_OFN15_test_se_i
+ RN=FE_OFN163_n4451 QN=n3643 Q=n30 D=n3602 CK=clk_i__L3_N13
XPCBuffer_reg[13] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_31_
+ SE=FE_OFN73_test_se_i RN=n4452 QN=n3644 Q=n29 D=n3601 CK=clk_i__L3_N27
XPCBuffer_reg[12] SDFFRXL $PINS SI=n29 SE=FE_OFN72_test_se_i RN=n4452 QN=n3645
+ Q=n28 D=n3600 CK=clk_i__L3_N27
XPCBuffer_reg[11] SDFFRXL $PINS SI=n32 SE=FE_OFN106_test_se_i RN=n4452 QN=n3646
+ Q=n27 D=n3599 CK=clk_i__L3_N26
XPCBuffer_reg[10] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_18_
+ SE=FE_OFN83_test_se_i RN=n4452 QN=n3647 Q=n26 D=n3598 CK=clk_i__L3_N27
XPCBuffer_reg[9] SDFFRXL $PINS SI=n746 SE=FE_OFN20_test_se_i RN=n4452 QN=n3648
+ Q=SPCASCAN_N29 D=n3597 CK=clk_i__L3_N26
XPCBuffer_reg[8] SDFFRXL $PINS SI=SPCASCAN_N23 SE=FE_OFN20_test_se_i RN=n4452
+ QN=n3649 Q=n24 D=n3596 CK=clk_i__L3_N26
XPCBuffer_reg[7] SDFFRXL $PINS SI=SPCASCAN_N25 SE=FE_OFN20_test_se_i RN=n4452
+ QN=n3650 Q=SPCBSCAN_N40 D=n3595 CK=clk_i__L3_N7
XPCBuffer_reg[6] SDFFRXL $PINS SI=n678 SE=FE_OFN87_test_se_i RN=n4452 QN=n3651
+ Q=n22 D=n3594 CK=clk_i__L3_N7
XPCBuffer_reg[5] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_3_ SE=FE_OFN8_test_se_i
+ RN=n4452 QN=n3652 Q=SPCASCAN_N25 D=n3593 CK=clk_i__L3_N7
XPCBuffer_reg[4] SDFFRXL $PINS SI=n19 SE=FE_OFN87_test_se_i RN=n4452 QN=n3653
+ Q=SPCASCAN_N26 D=n3592 CK=clk_i__L3_N7
XPCBuffer_reg[3] SDFFRXL $PINS SI=n22 SE=FE_OFN87_test_se_i RN=n4452 QN=n3654
+ Q=n19 D=n3591 CK=clk_i__L3_N7
XPCBuffer_reg[2] SDFFRXL $PINS SI=SPCASCAN_N24 SE=FE_OFN20_test_se_i RN=n4452
+ QN=n3655 Q=SPCASCAN_N23 D=n3590 CK=clk_i__L3_N26
XPCBuffer_reg[1] SDFFRXL $PINS SI=n675 SE=FE_OFN106_test_se_i RN=n4453 QN=n3656
+ Q=SPCASCAN_N27 D=n3589 CK=clk_i__L3_N26
XPCBuffer_reg[0] SDFFRXL $PINS SI=n600 SE=FE_OFN106_test_se_i RN=n4453 QN=n3657
+ Q=n32 D=n3588 CK=clk_i__L3_N26
XPCBuffer_reg[30] SDFFRXL $PINS SI=n4639 SE=FE_OFN72_test_se_i RN=n4453
+ QN=n3627 Q=n17 D=n3586 CK=clk_i__L3_N27
XPCBuffer_reg[29] SDFFRXL $PINS SI=n573 SE=FE_OFN73_test_se_i RN=n4453 QN=n3628
+ Q=n16 D=n3585 CK=clk_i__L3_N13
XPCBuffer_reg[28] SDFFRXL $PINS SI=n588 SE=FE_OFN73_test_se_i RN=n4453 QN=n3629
+ Q=n15 D=n3584 CK=clk_i__L3_N13
XPCBuffer_reg[27] SDFFRXL $PINS SI=n16 SE=FE_OFN73_test_se_i RN=n4453 QN=n3630
+ Q=SPCASCAN_N7 D=n3583 CK=clk_i__L3_N27
XPCBuffer_reg[26] SDFFRXL $PINS SI=n658 SE=FE_OFN73_test_se_i RN=n4453 QN=n3631
+ Q=n13 D=n3582 CK=clk_i__L3_N13
XPCBuffer_reg[25] SDFFRXL $PINS SI=n575 SE=FE_OFN73_test_se_i RN=n4453 QN=n3632
+ Q=n11 D=n3581 CK=clk_i__L3_N13
XPCBuffer_reg[24] SDFFRXL $PINS SI=n570 SE=FE_OFN72_test_se_i RN=n4453 QN=n3633
+ Q=n9 D=n3580 CK=clk_i__L3_N27
XPCBuffer_reg[23] SDFFRXL $PINS SI=n7 SE=FE_OFN93_test_se_i RN=n4453 QN=n3634
+ Q=n8 D=n3579 CK=clk_i__L3_N2
XPCBuffer_reg[22] SDFFRXL $PINS SI=n585 SE=FE_OFN99_test_se_i RN=n4453 QN=n3635
+ Q=n7 D=n3578 CK=clk_i__L3_N2
XPCBuffer_reg[21] SDFFRXL $PINS SI=n1 SE=FE_OFN101_test_se_i RN=FE_OFN147_n4455
+ QN=n3636 Q=n6 D=n3577 CK=clk_i__L3_N2
XPCBuffer_reg[20] SDFFRXL $PINS SI=n6 SE=FE_OFN101_test_se_i RN=FE_OFN147_n4455
+ QN=n3637 Q=n5 D=n3576 CK=clk_i__L3_N2
XPCBuffer_reg[19] SDFFRXL $PINS SI=n583 SE=FE_OFN101_test_se_i
+ RN=FE_OFN147_n4455 QN=n3638 Q=SPCASCAN_N12 D=n3575 CK=clk_i__L3_N2
XPCBuffer_reg[18] SDFFRXL $PINS SI=n579 SE=FE_OFN101_test_se_i
+ RN=FE_OFN147_n4455 QN=n3639 Q=n3 D=n3574 CK=clk_i__L3_N2
XPCBuffer_reg[17] SDFFRXL $PINS SI=n5 SE=FE_OFN101_test_se_i RN=FE_OFN147_n4455
+ QN=n3640 Q=n2 D=n3573 CK=clk_i__L3_N2
XPCBuffer_reg[16] SDFFRXL $PINS SI=SPCBSCAN_N39 SE=FE_OFN101_test_se_i
+ RN=FE_OFN147_n4455 QN=n3641 Q=n1 D=n3572 CK=clk_i__L3_N2
XMEM_reg[1] SDFFRXL $PINS SI=SPCASCAN_N16 SE=FE_OFN105_test_se_i RN=n4462
+ QN=n1743 Q=MEM[1] D=n3613 CK=clk_i__L3_N9
XImmediate_SE_reg[0] SDFFRXL $PINS SI=EX[5] SE=FE_OFN105_test_se_i
+ RN=FE_OFN148_n4462 QN=n601 Q=Immediate_SE[0] D=n141 CK=clk_i__L3_N24
XEX_reg[1] SDFFRXL $PINS SI=n38 SE=FE_OFN109_test_se_i RN=n4462 QN=n638 Q=n1945
+ D=n3606 CK=clk_i__L3_N9
XImmediate_SE_reg[15] SDFFRXL $PINS SI=n648 SE=FE_OFN110_test_se_i RN=n4461
+ QN=n607 Q=Immediate_SE[15] D=next_Immediate_SE[15] CK=clk_i__L3_N9
XImmediate_SE_reg[14] SDFFRXL $PINS SI=n605 SE=FE_OFN110_test_se_i RN=n4461
+ QN=n606 Q=Immediate_SE[14] D=n155 CK=clk_i__L3_N9
XImmediate_SE_reg[13] SDFFRXL $PINS SI=n607 SE=FE_OFN110_test_se_i RN=n4461
+ QN=n605 Q=Immediate_SE[13] D=n154 CK=clk_i__L3_N9
XImmediate_SE_reg[11] SDFFRXL $PINS SI=n604 SE=FE_OFN110_test_se_i RN=n4461
+ QN=n603 Q=Immediate_SE[11] D=n153 CK=clk_i__L3_N9
XImmediate_SE_reg[10] SDFFRXL $PINS SI=n603 SE=FE_OFN109_test_se_i RN=n4461
+ QN=SPCASCAN_N17 Q=Immediate_SE[10] D=n152 CK=clk_i__L3_N9
XImmediate_SE_reg[9] SDFFRXL $PINS SI=n1669 SE=FE_OFN105_test_se_i RN=n4461
+ QN=n1675 Q=Immediate_SE[9] D=n151 CK=clk_i__L3_N24
XImmediate_SE_reg[8] SDFFRXL $PINS SI=n1675 SE=FE_OFN105_test_se_i RN=n4461
+ QN=n1673 Q=Immediate_SE[8] D=n147 CK=clk_i__L3_N24
XImmediate_SE_reg[7] SDFFRXL $PINS SI=n1673 SE=FE_OFN105_test_se_i RN=n4461
+ QN=SPCASCAN_N13 Q=Immediate_SE[7] D=n150 CK=clk_i__L3_N24
XImmediate_SE_reg[6] SDFFRXL $PINS SI=SPCASCAN_N14 SE=FE_OFN105_test_se_i
+ RN=n4461 QN=n1669 Q=Immediate_SE[6] D=n149 CK=clk_i__L3_N24
XImmediate_SE_reg[4] SDFFRXL $PINS SI=n624 SE=FE_OFN23_test_se_i
+ RN=FE_OFN148_n4462 QN=SPCASCAN_N15 Q=Immediate_SE[4] D=n145 CK=clk_i__L3_N24
XPCBuffer_valid_reg SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_9_
+ SE=FE_OFN106_test_se_i RN=n4462 QN=n3658 Q=PCBuffer_valid D=n3604
+ CK=clk_i__L3_N25
XImmediate_SE_reg[3] SDFFRXL $PINS SI=n612 SE=FE_OFN23_test_se_i
+ RN=FE_OFN148_n4462 QN=n624 Q=Immediate_SE[3] D=n144 CK=clk_i__L3_N24
XRegisterRs_reg[4] SDFFRXL $PINS SI=SPCASCAN_N21 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n652 Q=RegisterRs[4] D=n3625 CK=clk_i__L3_N9
Xregfile_reg[31][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n653
+ SE=FE_OFN72_test_se_i RN=n4462 QN=n569 Q=regfile[31][31] D=n3690
+ CKN=clk_i__L3_N27
Xregfile_reg[31][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n17
+ SE=FE_OFN72_test_se_i RN=n4462 QN=n570 Q=regfile[31][30] D=n3689
+ CKN=clk_i__L3_N27
Xregfile_reg[31][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n11
+ SE=FE_OFN73_test_se_i RN=FE_OFN163_n4451 QN=n571 Q=regfile[31][29] D=n3688
+ CKN=clk_i__L3_N13
Xregfile_reg[31][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n656
+ SE=FE_OFN73_test_se_i RN=FE_OFN163_n4451 QN=n572 Q=regfile[31][28] D=n3687
+ CKN=clk_i__L3_N13
Xregfile_reg[31][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n15
+ SE=FE_OFN73_test_se_i RN=FE_OFN163_n4451 QN=n573 Q=regfile[31][27] D=n3686
+ CKN=clk_i__L3_N13
Xregfile_reg[31][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n655
+ SE=FE_OFN73_test_se_i RN=FE_OFN163_n4451 QN=n574 Q=regfile[31][26] D=n3685
+ CKN=clk_i__L3_N13
Xregfile_reg[31][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n587
+ SE=FE_OFN15_test_se_i RN=FE_OFN163_n4451 QN=n575 Q=regfile[31][25] D=n3684
+ CKN=clk_i__L3_N13
Xregfile_reg[31][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=SPCASCAN_N6
+ SE=FE_OFN72_test_se_i RN=FE_OFN163_n4451 QN=SPCASCAN_N5 Q=regfile[31][24]
+ D=n3683 CKN=clk_i__L3_N27
Xregfile_reg[31][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n3
+ SE=FE_OFN99_test_se_i RN=FE_OFN163_n4451 QN=n577 Q=regfile[31][23] D=n3682
+ CKN=clk_i__L3_N2
Xregfile_reg[31][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n577
+ SE=FE_OFN99_test_se_i RN=FE_OFN163_n4451 QN=n578 Q=regfile[31][22] D=n3681
+ CKN=clk_i__L3_N2
Xregfile_reg[31][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n2
+ SE=FE_OFN100_test_se_i RN=FE_OFN163_n4451 QN=n579 Q=regfile[31][21] D=n3680
+ CKN=clk_i__L3_N2
Xregfile_reg[31][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n581
+ SE=FE_OFN101_test_se_i RN=FE_OFN163_n4451 QN=n580 Q=regfile[31][20] D=n3679
+ CKN=clk_i__L3_N2
Xregfile_reg[31][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET
+ SI=FE_PT1_ICACHE_addr_i_26_ SE=FE_OFN68_test_se_i RN=FE_OFN163_n4451 QN=n581
+ Q=regfile[31][19] D=n3678 CKN=clk_i__L3_N2
Xregfile_reg[31][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n584
+ SE=FE_OFN68_test_se_i RN=FE_OFN163_n4451 QN=n582 Q=regfile[31][18] D=n3677
+ CKN=clk_i__L3_N2
Xregfile_reg[31][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n582
+ SE=FE_OFN68_test_se_i RN=FE_OFN163_n4451 QN=n583 Q=regfile[31][17] D=n3676
+ CKN=clk_i__L3_N2
Xregfile_reg[31][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n580
+ SE=FE_OFN101_test_se_i RN=FE_OFN163_n4451 QN=n584 Q=regfile[31][16] D=n3675
+ CKN=clk_i__L3_N2
Xregfile_reg[31][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n578
+ SE=FE_OFN99_test_se_i RN=FE_OFN163_n4451 QN=n585 Q=regfile[31][15] D=n3674
+ CKN=clk_i__L3_N15
Xregfile_reg[31][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n31
+ SE=FE_OFN21_test_se_i RN=FE_OFN163_n4451 QN=n586 Q=regfile[31][14] D=n3673
+ CKN=clk_i__L3_N15
Xregfile_reg[31][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n30
+ SE=FE_OFN15_test_se_i RN=FE_OFN163_n4451 QN=n587 Q=regfile[31][13] D=n3672
+ CKN=clk_i__L3_N13
Xregfile_reg[31][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n654
+ SE=FE_OFN18_test_se_i RN=FE_OFN163_n4451 QN=n588 Q=regfile[31][12] D=n3671
+ CKN=clk_i__L3_N13
Xregfile_reg[31][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n705
+ SE=FE_OFN83_test_se_i RN=n4465 QN=n589 Q=regfile[31][11] D=n3670
+ CKN=clk_i__L3_N26
Xregfile_reg[31][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=test_so1
+ SE=FE_OFN83_test_se_i RN=n4465 QN=n590 Q=regfile[31][10] D=n3669
+ CKN=clk_i__L3_N27
Xregfile_reg[31][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET
+ SI=FE_PT1_ICACHE_addr_i_8_ SE=FE_OFN106_test_se_i RN=n4465 QN=n591
+ Q=regfile[31][9] D=n3668 CKN=clk_i__L3_N26
Xregfile_reg[31][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n599
+ SE=FE_OFN106_test_se_i RN=n4465 QN=SPCASCAN_N3 Q=regfile[31][8] D=n3667
+ CKN=clk_i__L3_N26
Xregfile_reg[31][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n597
+ SE=FE_OFN87_test_se_i RN=n4465 QN=n593 Q=regfile[31][7] D=n3666
+ CKN=clk_i__L3_N7
Xregfile_reg[31][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n593
+ SE=FE_OFN89_test_se_i RN=n4465 QN=n594 Q=regfile[31][6] D=n3665
+ CKN=clk_i__L3_N7
Xregfile_reg[31][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=SPCASCAN_N1
+ SE=FE_OFN89_test_se_i RN=n4465 QN=SPCBSCAN_N38 Q=regfile[31][5] D=n3664
+ CKN=clk_i__L3_N7
Xregfile_reg[31][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n594
+ SE=FE_OFN89_test_se_i RN=n4465 QN=SPCASCAN_N1 Q=regfile[31][4] D=n3663
+ CKN=clk_i__L3_N7
Xregfile_reg[31][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n598
+ SE=FE_OFN87_test_se_i RN=n4465 QN=n597 Q=regfile[31][3] D=n3662
+ CKN=clk_i__L3_N26
Xregfile_reg[31][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n591
+ SE=FE_OFN20_test_se_i RN=n4465 QN=n598 Q=regfile[31][2] D=n3661
+ CKN=clk_i__L3_N26
Xregfile_reg[31][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n27
+ SE=FE_OFN106_test_se_i RN=n4465 QN=n599 Q=regfile[31][1] D=n3660
+ CKN=clk_i__L3_N26
Xregfile_reg[31][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n590
+ SE=FE_OFN83_test_se_i RN=n4465 QN=n600 Q=regfile[31][0] D=n3659
+ CKN=clk_i__L3_N26
Xregfile_reg[27][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n1038
+ SE=FE_OFN82_test_se_i RN=n4473 QN=n749 Q=regfile[27][31] D=n3340
+ CKN=clk_i__L3_N12
Xregfile_reg[27][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n1102
+ SE=FE_OFN82_test_se_i RN=n4473 QN=n750 Q=regfile[27][30] D=n3338
+ CKN=clk_i__L3_N12
Xregfile_reg[27][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n784
+ SE=FE_OFN71_test_se_i RN=FE_OFN156_n4473 QN=n751 Q=regfile[27][29] D=n3336
+ CKN=clk_i__L3_N12
Xregfile_reg[27][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n816
+ SE=FE_OFN92_test_se_i RN=FE_OFN156_n4473 QN=n752 Q=regfile[27][28] D=n3334
+ CKN=clk_i__L3_N14
Xregfile_reg[27][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n785
+ SE=FE_OFN92_test_se_i RN=FE_OFN156_n4473 QN=n753 Q=regfile[27][27] D=n3332
+ CKN=clk_i__L3_N23
Xregfile_reg[27][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n786
+ SE=FE_OFN71_test_se_i RN=FE_OFN156_n4473 QN=n754 Q=regfile[27][26] D=n3330
+ CKN=clk_i__L3_N14
Xregfile_reg[27][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n767
+ SE=FE_OFN71_test_se_i RN=FE_OFN156_n4473 QN=n755 Q=regfile[27][25] D=n3328
+ CKN=clk_i__L3_N14
Xregfile_reg[27][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n814
+ SE=FE_OFN82_test_se_i RN=n4473 QN=n756 Q=regfile[27][24] D=n3326
+ CKN=clk_i__L3_N12
Xregfile_reg[27][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n758
+ SE=FE_OFN19_test_se_i RN=FE_OFN156_n4473 QN=n757 Q=regfile[27][23] D=n3324
+ CKN=clk
Xregfile_reg[27][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n1173
+ SE=FE_OFN19_test_se_i RN=FE_OFN156_n4473 QN=n758 Q=regfile[27][22] D=n3322
+ CKN=clk_i__L3_N5
Xregfile_reg[27][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n825
+ SE=FE_OFN61_test_se_i RN=FE_OFN156_n4473 QN=n759 Q=regfile[27][21] D=n3320
+ CKN=clk
Xregfile_reg[27][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n764
+ SE=FE_OFN61_test_se_i RN=FE_OFN156_n4473 QN=n760 Q=regfile[27][20] D=n3318
+ CKN=clk
Xregfile_reg[27][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1207
+ SE=FE_OFN61_test_se_i RN=FE_OFN156_n4473 QN=n761 Q=regfile[27][19] D=n3316
+ CKN=clk_i__L3_N4
Xregfile_reg[27][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n791
+ SE=FE_OFN62_test_se_i RN=FE_OFN156_n4473 QN=n762 Q=regfile[27][18] D=n3314
+ CKN=clk_i__L3_N4
Xregfile_reg[27][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n795
+ SE=FE_OFN63_test_se_i RN=FE_OFN156_n4473 QN=n763 Q=regfile[27][17] D=n3312
+ CKN=clk_i__L3_N5
Xregfile_reg[27][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n759
+ SE=FE_OFN61_test_se_i RN=FE_OFN156_n4473 QN=n764 Q=regfile[27][16] D=n3310
+ CKN=clk
Xregfile_reg[27][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1171
+ SE=FE_OFN77_test_se_i RN=FE_OFN156_n4473 QN=n765 Q=regfile[27][15] D=n3308
+ CKN=clk_i__L3_N14
Xregfile_reg[27][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1142
+ SE=FE_OFN60_test_se_i RN=FE_OFN156_n4473 QN=n766 Q=regfile[27][14] D=n3306
+ CKN=clk
Xregfile_reg[27][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n799
+ SE=FE_OFN70_test_se_i RN=FE_OFN157_n4472 QN=n767 Q=regfile[27][13] D=n3304
+ CKN=clk_i__L3_N14
Xregfile_reg[27][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n783
+ SE=FE_OFN71_test_se_i RN=FE_OFN157_n4472 QN=n768 Q=regfile[27][12] D=n3302
+ CKN=clk_i__L3_N14
Xregfile_reg[27][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n833
+ SE=FE_OFN84_test_se_i RN=n4472 QN=n769 Q=regfile[27][11] D=n3300
+ CKN=clk_i__L3_N22
Xregfile_reg[27][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n801
+ SE=FE_OFN85_test_se_i RN=n4472 QN=n770 Q=regfile[27][10] D=n3298
+ CKN=clk_i__L3_N23
Xregfile_reg[27][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n803
+ SE=FE_OFN84_test_se_i RN=n4472 QN=n771 Q=regfile[27][9] D=n3296
+ CKN=clk_i__L3_N22
Xregfile_reg[27][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n835
+ SE=FE_OFN91_test_se_i RN=n4472 QN=n772 Q=regfile[27][8] D=n3294
+ CKN=clk_i__L3_N22
Xregfile_reg[27][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n841
+ SE=FE_OFN90_test_se_i RN=n4472 QN=n773 Q=regfile[27][7] D=n3292
+ CKN=clk_i__L3_N8
Xregfile_reg[27][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n806
+ SE=FE_OFN90_test_se_i RN=n4472 QN=n774 Q=regfile[27][6] D=n3290
+ CKN=clk_i__L3_N8
Xregfile_reg[27][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n807
+ SE=FE_OFN0_test_se_i RN=n4472 QN=n775 Q=regfile[27][5] D=n3288 CKN=clk_i__L3_N8
Xregfile_reg[27][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n872
+ SE=FE_OFN12_test_se_i RN=n4472 QN=n776 Q=regfile[27][4] D=n3286
+ CKN=clk_i__L3_N8
Xregfile_reg[27][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1353
+ SE=FE_OFN90_test_se_i RN=n4472 QN=n777 Q=regfile[27][3] D=n3284
+ CKN=clk_i__L3_N8
Xregfile_reg[27][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n874
+ SE=FE_OFN91_test_se_i RN=n4472 QN=n778 Q=regfile[27][2] D=n3282
+ CKN=clk_i__L3_N8
Xregfile_reg[27][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n811
+ SE=FE_OFN84_test_se_i RN=n4472 QN=n779 Q=regfile[27][1] D=n3280
+ CKN=clk_i__L3_N6
Xregfile_reg[27][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n865
+ SE=FE_OFN84_test_se_i RN=n4472 QN=n780 Q=regfile[27][0] D=n3278
+ CKN=clk_i__L3_N22
Xregfile_reg[23][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n941
+ SE=FE_OFN72_test_se_i RN=n4477 QN=n877 Q=regfile[23][31] D=n3084
+ CKN=clk_i__L3_N12
Xregfile_reg[23][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n945
+ SE=FE_OFN18_test_se_i RN=n4477 QN=n878 Q=regfile[23][30] D=n3082
+ CKN=clk_i__L3_N12
Xregfile_reg[23][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n882
+ SE=FE_OFN13_test_se_i RN=n4477 QN=n879 Q=regfile[23][29] D=n3080
+ CKN=clk_i__L3_N13
Xregfile_reg[23][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n881
+ SE=FE_OFN18_test_se_i RN=n4477 QN=n880 Q=regfile[23][28] D=n3078
+ CKN=clk_i__L3_N13
Xregfile_reg[23][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n718
+ SE=FE_OFN18_test_se_i RN=n4477 QN=n881 Q=regfile[23][27] D=n3076
+ CKN=clk_i__L3_N13
Xregfile_reg[23][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n992
+ SE=FE_OFN102_test_se_i RN=n4477 QN=n882 Q=regfile[23][26] D=n3074
+ CKN=clk_i__L3_N13
Xregfile_reg[23][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n947
+ SE=FE_OFN99_test_se_i RN=n4477 QN=n883 Q=regfile[23][25] D=n3072
+ CKN=clk_i__L3_N15
Xregfile_reg[23][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n660
+ SE=FE_OFN82_test_se_i RN=n4477 QN=n884 Q=regfile[23][24] D=n3070
+ CKN=clk_i__L3_N27
Xregfile_reg[23][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n918
+ SE=FE_OFN60_test_se_i RN=n4477 QN=n885 Q=regfile[23][23] D=n3068 CKN=clk
Xregfile_reg[23][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n1110
+ SE=FE_OFN100_test_se_i RN=n4477 QN=n886 Q=regfile[23][22] D=n3066 CKN=clk
Xregfile_reg[23][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n1049
+ SE=FE_OFN67_test_se_i RN=n4477 QN=n887 Q=regfile[23][21] D=n3064
+ CKN=clk_i__L3_N1
Xregfile_reg[23][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n1020
+ SE=FE_OFN60_test_se_i RN=n4477 QN=n888 Q=regfile[23][20] D=n3062 CKN=clk
Xregfile_reg[23][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n922
+ SE=FE_OFN67_test_se_i RN=n4477 QN=n889 Q=regfile[23][19] D=n3060
+ CKN=clk_i__L3_N1
Xregfile_reg[23][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n923
+ SE=FE_OFN67_test_se_i RN=n4477 QN=n890 Q=regfile[23][18] D=n3058
+ CKN=clk_i__L3_N1
Xregfile_reg[23][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n956
+ SE=FE_OFN67_test_se_i RN=n4477 QN=n891 Q=regfile[23][17] D=n3056
+ CKN=clk_i__L3_N1
Xregfile_reg[23][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n887
+ SE=FE_OFN67_test_se_i RN=n4477 QN=n892 Q=regfile[23][16] D=n3054
+ CKN=clk_i__L3_N1
Xregfile_reg[23][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n662
+ SE=FE_OFN99_test_se_i RN=FE_OFN151_n4481 QN=n893 Q=regfile[23][15] D=n3052
+ CKN=clk_i__L3_N15
Xregfile_reg[23][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1021
+ SE=FE_OFN99_test_se_i RN=FE_OFN151_n4481 QN=n894 Q=regfile[23][14] D=n3050
+ CKN=clk_i__L3_N15
Xregfile_reg[23][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n959
+ SE=FE_OFN102_test_se_i RN=FE_OFN151_n4481 QN=n895 Q=regfile[23][13] D=n3048
+ CKN=clk_i__L3_N15
Xregfile_reg[23][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n960
+ SE=FE_OFN102_test_se_i RN=FE_OFN151_n4481 QN=n896 Q=regfile[23][12] D=n3046
+ CKN=clk_i__L3_N15
Xregfile_reg[23][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n929
+ SE=FE_OFN86_test_se_i RN=n4481 QN=n897 Q=regfile[23][11] D=n3044
+ CKN=clk_i__L3_N26
Xregfile_reg[23][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n940
+ SE=FE_OFN86_test_se_i RN=n4481 QN=n898 Q=regfile[23][10] D=n3042
+ CKN=clk_i__L3_N27
Xregfile_reg[23][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n963
+ SE=FE_OFN88_test_se_i RN=n4481 QN=n899 Q=regfile[23][9] D=n3040
+ CKN=clk_i__L3_N6
Xregfile_reg[23][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n714
+ SE=FE_OFN88_test_se_i RN=n4481 QN=n900 Q=regfile[23][8] D=n3038
+ CKN=clk_i__L3_N26
Xregfile_reg[23][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n934
+ SE=FE_OFN89_test_se_i RN=n4481 QN=n901 Q=regfile[23][7] D=n3036
+ CKN=clk_i__L3_N7
Xregfile_reg[23][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n969
+ SE=FE_OFN87_test_se_i RN=n4481 QN=n902 Q=regfile[23][6] D=n3034
+ CKN=clk_i__L3_N7
Xregfile_reg[23][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n1062
+ SE=FE_OFN9_test_se_i RN=n4481 QN=n903 Q=regfile[23][5] D=n3032 CKN=clk_i__L3_N7
Xregfile_reg[23][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n968
+ SE=FE_OFN87_test_se_i RN=n4481 QN=n904 Q=regfile[23][4] D=n3030
+ CKN=clk_i__L3_N7
Xregfile_reg[23][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n938
+ SE=FE_OFN88_test_se_i RN=n4481 QN=n905 Q=regfile[23][3] D=n3028
+ CKN=clk_i__L3_N7
Xregfile_reg[23][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET
+ SI=FE_PT1_ICACHE_addr_i_5_ SE=FE_OFN88_test_se_i RN=n4481 QN=n906
+ Q=regfile[23][2] D=n3026 CKN=clk_i__L3_N26
Xregfile_reg[23][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n715
+ SE=FE_OFN88_test_se_i RN=n4481 QN=n907 Q=regfile[23][1] D=n3024
+ CKN=clk_i__L3_N26
Xregfile_reg[23][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n898
+ SE=FE_OFN86_test_se_i RN=n4481 QN=n908 Q=regfile[23][0] D=n3022
+ CKN=clk_i__L3_N26
Xregfile_reg[19][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n1044
+ SE=FE_OFN82_test_se_i RN=n4484 QN=n1005 Q=regfile[19][31] D=n2828
+ CKN=clk_i__L3_N6
Xregfile_reg[19][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1009
+ SE=FE_OFN82_test_se_i RN=n4484 QN=n1006 Q=regfile[19][30] D=n2826
+ CKN=clk_i__L3_N12
Xregfile_reg[19][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n914
+ SE=FE_OFN75_test_se_i RN=n4484 QN=n1007 Q=regfile[19][29] D=n2824
+ CKN=clk_i__L3_N12
Xregfile_reg[19][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n1072
+ SE=FE_OFN75_test_se_i RN=n4484 QN=n1008 Q=regfile[19][28] D=n2822
+ CKN=clk_i__L3_N12
Xregfile_reg[19][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n913
+ SE=FE_OFN82_test_se_i RN=n4484 QN=n1009 Q=regfile[19][27] D=n2820
+ CKN=clk_i__L3_N12
Xregfile_reg[19][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1056
+ SE=FE_OFN75_test_se_i RN=n4484 QN=n1010 Q=regfile[19][26] D=n2818
+ CKN=clk_i__L3_N15
Xregfile_reg[19][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1022
+ SE=FE_OFN77_test_se_i RN=n4484 QN=n1011 Q=regfile[19][25] D=n2816
+ CKN=clk_i__L3_N15
Xregfile_reg[19][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1108
+ SE=FE_OFN86_test_se_i RN=n4484 QN=n1012 Q=regfile[19][24] D=n2814
+ CKN=clk_i__L3_N6
Xregfile_reg[19][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n855
+ SE=FE_OFN60_test_se_i RN=n4484 QN=n1013 Q=regfile[19][23] D=n2812 CKN=clk
Xregfile_reg[19][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1045
+ SE=FE_OFN60_test_se_i RN=n4484 QN=n1014 Q=regfile[19][22] D=n2810 CKN=clk
Xregfile_reg[19][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n823
+ SE=FE_OFN62_test_se_i RN=n4484 QN=n1015 Q=regfile[19][21] D=n2808 CKN=clk
Xregfile_reg[19][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n826
+ SE=FE_OFN61_test_se_i RN=n4484 QN=n1016 Q=regfile[19][20] D=n2806 CKN=clk
Xregfile_reg[19][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1115
+ SE=FE_OFN62_test_se_i RN=n4484 QN=n1017 Q=regfile[19][19] D=n2804
+ CKN=clk_i__L3_N1
Xregfile_reg[19][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n1017
+ SE=FE_OFN62_test_se_i RN=n4484 QN=n1018 Q=regfile[19][18] D=n2802 CKN=clk
Xregfile_reg[19][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n1015
+ SE=FE_OFN62_test_se_i RN=n4485 QN=n1019 Q=regfile[19][17] D=n2800 CKN=clk
Xregfile_reg[19][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n1019
+ SE=FE_OFN60_test_se_i RN=n4485 QN=n1020 Q=regfile[19][16] D=n2798 CKN=clk
Xregfile_reg[19][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1119
+ SE=FE_OFN77_test_se_i RN=n4485 QN=n1021 Q=regfile[19][15] D=n2796
+ CKN=clk_i__L3_N15
Xregfile_reg[19][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n1118
+ SE=FE_OFN77_test_se_i RN=n4485 QN=n1022 Q=regfile[19][14] D=n2794
+ CKN=clk_i__L3_N15
Xregfile_reg[19][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n1024
+ SE=FE_OFN77_test_se_i RN=n4485 QN=n1023 Q=regfile[19][13] D=n2792
+ CKN=clk_i__L3_N15
Xregfile_reg[19][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n1120
+ SE=FE_OFN75_test_se_i RN=n4485 QN=n1024 Q=regfile[19][12] D=n2790
+ CKN=clk_i__L3_N15
Xregfile_reg[19][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n972
+ SE=FE_OFN86_test_se_i RN=n4485 QN=n1025 Q=regfile[19][11] D=n2788
+ CKN=clk_i__L3_N6
Xregfile_reg[19][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n1004
+ SE=FE_OFN86_test_se_i RN=n4485 QN=n1026 Q=regfile[19][10] D=n2786
+ CKN=clk_i__L3_N6
Xregfile_reg[19][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n836
+ SE=FE_OFN113_test_se_i RN=n4485 QN=n1027 Q=regfile[19][9] D=n2784
+ CKN=clk_i__L3_N6
Xregfile_reg[19][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n1092
+ SE=FE_OFN113_test_se_i RN=n4485 QN=n1028 Q=regfile[19][8] D=n2782
+ CKN=clk_i__L3_N8
Xregfile_reg[19][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n1128
+ SE=FE_OFN87_test_se_i RN=n4485 QN=n1029 Q=regfile[19][7] D=n2780
+ CKN=clk_i__L3_N8
Xregfile_reg[19][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_99_NET SI=n967
+ SE=FE_OFN9_test_se_i RN=n4485 QN=n1030 Q=regfile[19][6] D=n2778
+ CKN=clk_i__L3_N7
Xregfile_reg[19][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_99_NET SI=n1032
+ SE=FE_OFN112_test_se_i RN=n4485 QN=n1031 Q=regfile[19][5] D=n2776
+ CKN=clk_i__L3_N8
Xregfile_reg[19][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n1030
+ SE=FE_OFN9_test_se_i RN=n4485 QN=n1032 Q=regfile[19][4] D=n2774
+ CKN=clk_i__L3_N8
Xregfile_reg[19][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1065
+ SE=FE_OFN113_test_se_i RN=n4485 QN=n1033 Q=regfile[19][3] D=n2772
+ CKN=clk_i__L3_N8
Xregfile_reg[19][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1066
+ SE=FE_OFN113_test_se_i RN=n4485 QN=n1034 Q=regfile[19][2] D=n2770
+ CKN=clk_i__L3_N8
Xregfile_reg[19][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n1131
+ SE=FE_OFN85_test_se_i RN=n4485 QN=n1035 Q=regfile[19][1] D=n2768
+ CKN=clk_i__L3_N6
Xregfile_reg[19][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1067
+ SE=FE_OFN85_test_se_i RN=n4485 QN=n1036 Q=regfile[19][0] D=n2766
+ CKN=clk_i__L3_N6
Xregfile_reg[15][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n1165
+ SE=FE_OFN81_test_se_i RN=n4491 QN=n1133 Q=regfile[15][31] D=n2572
+ CKN=clk_i__L3_N23
Xregfile_reg[15][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n1166
+ SE=FE_OFN91_test_se_i RN=n4491 QN=n1134 Q=regfile[15][30] D=n2570
+ CKN=clk_i__L3_N23
Xregfile_reg[15][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n1167
+ SE=FE_OFN71_test_se_i RN=n4491 QN=n1135 Q=regfile[15][29] D=n2568
+ CKN=clk_i__L3_N14
Xregfile_reg[15][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1232
+ SE=FE_OFN92_test_se_i RN=n4491 QN=n1136 Q=regfile[15][28] D=n2566
+ CKN=clk_i__L3_N14
Xregfile_reg[15][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1134
+ SE=FE_OFN92_test_se_i RN=n4491 QN=n1137 Q=regfile[15][27] D=n2564
+ CKN=clk_i__L3_N23
Xregfile_reg[15][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n1234
+ SE=FE_OFN71_test_se_i RN=n4491 QN=n1138 Q=regfile[15][26] D=n2562
+ CKN=clk_i__L3_N14
Xregfile_reg[15][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n797
+ SE=FE_OFN70_test_se_i RN=n4491 QN=n1139 Q=regfile[15][25] D=n2560
+ CKN=clk_i__L3_N14
Xregfile_reg[15][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n788
+ SE=FE_OFN81_test_se_i RN=n4491 QN=n1140 Q=regfile[15][24] D=n2558
+ CKN=clk_i__L3_N23
Xregfile_reg[15][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n1205
+ SE=FE_OFN70_test_se_i RN=n4491 QN=n1141 Q=regfile[15][23] D=n2556
+ CKN=clk_i__L3_N5
Xregfile_reg[15][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n790
+ SE=FE_OFN70_test_se_i RN=n4491 QN=n1142 Q=regfile[15][22] D=n2554 CKN=clk
Xregfile_reg[15][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1176
+ SE=FE_OFN63_test_se_i RN=n4491 QN=n1143 Q=regfile[15][21] D=n2552
+ CKN=clk_i__L3_N4
Xregfile_reg[15][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n1148
+ SE=FE_OFN63_test_se_i RN=n4491 QN=n1144 Q=regfile[15][20] D=n2550
+ CKN=clk_i__L3_N5
Xregfile_reg[15][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n1333
+ SE=FE_OFN63_test_se_i RN=n4492 QN=n1145 Q=regfile[15][19] D=n2548
+ CKN=clk_i__L3_N5
Xregfile_reg[15][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n1147
+ SE=FE_OFN63_test_se_i RN=n4492 QN=n1146 Q=regfile[15][18] D=n2546
+ CKN=clk_i__L3_N5
Xregfile_reg[15][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n1144
+ SE=FE_OFN63_test_se_i RN=n4492 QN=n1147 Q=regfile[15][17] D=n2544
+ CKN=clk_i__L3_N5
Xregfile_reg[15][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n789
+ SE=FE_OFN63_test_se_i RN=n4492 QN=n1148 Q=regfile[15][16] D=n2542
+ CKN=clk_i__L3_N5
Xregfile_reg[15][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1182
+ SE=FE_OFN69_test_se_i RN=n4492 QN=n1149 Q=regfile[15][15] D=n2540
+ CKN=clk_i__L3_N18
Xregfile_reg[15][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n1214
+ SE=FE_OFN17_test_se_i RN=n4492 QN=n1150 Q=regfile[15][14] D=n2538
+ CKN=clk_i__L3_N5
Xregfile_reg[15][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1395
+ SE=FE_OFN69_test_se_i RN=n4492 QN=n1151 Q=regfile[15][13] D=n2536
+ CKN=clk_i__L3_N14
Xregfile_reg[15][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n1295
+ SE=FE_OFN69_test_se_i RN=n4492 QN=n1152 Q=regfile[15][12] D=n2534
+ CKN=clk_i__L3_N14
Xregfile_reg[15][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1260
+ SE=FE_OFN81_test_se_i RN=n4492 QN=n1153 Q=regfile[15][11] D=n2532
+ CKN=clk_i__L3_N23
Xregfile_reg[15][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1249
+ SE=FE_OFN115_test_se_i RN=n4492 QN=n1154 Q=regfile[15][10] D=n2530
+ CKN=clk_i__L3_N23
Xregfile_reg[15][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1388
+ SE=FE_OFN80_test_se_i RN=n4492 QN=n1155 Q=regfile[15][9] D=n2528
+ CKN=clk_i__L3_N22
Xregfile_reg[15][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1188
+ SE=FE_OFN80_test_se_i RN=n4492 QN=n1156 Q=regfile[15][8] D=n2526
+ CKN=clk_i__L3_N20
Xregfile_reg[15][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n1448
+ SE=FE_OFN79_test_se_i RN=n4492 QN=n1157 Q=regfile[15][7] D=n2524
+ CKN=clk_i__L3_N21
Xregfile_reg[15][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n1256
+ SE=FE_OFN79_test_se_i RN=n4492 QN=n1158 Q=regfile[15][6] D=n2522
+ CKN=clk_i__L3_N21
Xregfile_reg[15][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n1160
+ SE=FE_OFN79_test_se_i RN=n4492 QN=n1159 Q=regfile[15][5] D=n2520
+ CKN=clk_i__L3_N21
Xregfile_reg[15][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n1224
+ SE=FE_OFN12_test_se_i RN=n4492 QN=n1160 Q=regfile[15][4] D=n2518
+ CKN=clk_i__L3_N8
Xregfile_reg[15][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1193
+ SE=FE_OFN90_test_se_i RN=n4492 QN=n1161 Q=regfile[15][3] D=n2516
+ CKN=clk_i__L3_N8
Xregfile_reg[15][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1194
+ SE=FE_OFN91_test_se_i RN=n4492 QN=n1162 Q=regfile[15][2] D=n2514
+ CKN=clk_i__L3_N22
Xregfile_reg[15][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1195
+ SE=FE_OFN84_test_se_i RN=n4493 QN=n1163 Q=regfile[15][1] D=n2512
+ CKN=clk_i__L3_N22
Xregfile_reg[15][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n769
+ SE=FE_OFN84_test_se_i RN=n4493 QN=n1164 Q=regfile[15][0] D=n2510
+ CKN=clk_i__L3_N23
Xregfile_reg[11][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n1357
+ SE=FE_OFN57_test_se_i RN=n4498 QN=n1261 Q=regfile[11][31] D=n2316
+ CKN=clk_i__L3_N23
Xregfile_reg[11][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1391
+ SE=FE_OFN57_test_se_i RN=n4498 QN=n1262 Q=regfile[11][30] D=n2314
+ CKN=clk_i__L3_N23
Xregfile_reg[11][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1199
+ SE=FE_OFN71_test_se_i RN=n4498 QN=n1263 Q=regfile[11][29] D=n2312
+ CKN=clk_i__L3_N14
Xregfile_reg[11][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1266
+ SE=FE_OFN58_test_se_i RN=n4498 QN=n1264 Q=regfile[11][28] D=n2310
+ CKN=clk_i__L3_N14
Xregfile_reg[11][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1329
+ SE=FE_OFN56_test_se_i RN=n4498 QN=n1265 Q=regfile[11][27] D=n2308
+ CKN=clk_i__L3_N17
Xregfile_reg[11][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1488
+ SE=FE_OFN58_test_se_i RN=n4498 QN=n1266 Q=regfile[11][26] D=n2306
+ CKN=clk_i__L3_N14
Xregfile_reg[11][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1245
+ SE=FE_OFN69_test_se_i RN=n4498 QN=n1267 Q=regfile[11][25] D=n2304
+ CKN=clk_i__L3_N18
Xregfile_reg[11][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1396
+ SE=FE_OFN11_test_se_i RN=n4498 QN=n1268 Q=regfile[11][24] D=n2302
+ CKN=clk_i__L3_N23
Xregfile_reg[11][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1299
+ SE=FE_OFN70_test_se_i RN=n4498 QN=n1269 Q=regfile[11][23] D=n2300
+ CKN=clk_i__L3_N5
Xregfile_reg[11][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n1269
+ SE=FE_OFN69_test_se_i RN=n4498 QN=n1270 Q=regfile[11][22] D=n2298
+ CKN=clk_i__L3_N5
Xregfile_reg[11][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n1367
+ SE=FE_OFN17_test_se_i RN=n4499 QN=n1271 Q=regfile[11][21] D=n2296
+ CKN=clk_i__L3_N4
Xregfile_reg[11][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n1271
+ SE=FE_OFN17_test_se_i RN=n4499 QN=n1272 Q=regfile[11][20] D=n2294
+ CKN=clk_i__L3_N4
Xregfile_reg[11][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1337
+ SE=FE_OFN66_test_se_i RN=n4499 QN=n1273 Q=regfile[11][19] D=n2292
+ CKN=clk_i__L3_N4
Xregfile_reg[11][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n1370
+ SE=FE_OFN65_test_se_i RN=n4499 QN=n1274 Q=regfile[11][18] D=n2290
+ CKN=clk_i__L3_N4
Xregfile_reg[11][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n1307
+ SE=FE_OFN55_test_se_i RN=n4499 QN=n1275 Q=regfile[11][17] D=n2288
+ CKN=clk_i__L3_N3
Xregfile_reg[11][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1591
+ SE=FE_OFN55_test_se_i RN=n4499 QN=n1276 Q=regfile[11][16] D=n2286
+ CKN=clk_i__L3_N3
Xregfile_reg[11][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1501
+ SE=FE_OFN76_test_se_i RN=n4499 QN=n1277 Q=regfile[11][15] D=n2284
+ CKN=clk_i__L3_N18
Xregfile_reg[11][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1277
+ SE=FE_OFN76_test_se_i RN=n4499 QN=n1278 Q=regfile[11][14] D=n2282
+ CKN=clk_i__L3_N3
Xregfile_reg[11][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1471
+ SE=FE_OFN1_test_se_i RN=n4499 QN=n1279 Q=regfile[11][13] D=n2280
+ CKN=clk_i__L3_N18
Xregfile_reg[11][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1440
+ SE=FE_OFN74_test_se_i RN=n4499 QN=n1280 Q=regfile[11][12] D=n2278
+ CKN=clk_i__L3_N18
Xregfile_reg[11][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1313
+ SE=FE_OFN3_test_se_i RN=n4499 QN=n1281 Q=regfile[11][11] D=n2276
+ CKN=clk_i__L3_N20
Xregfile_reg[11][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1379
+ SE=FE_OFN115_test_se_i RN=n4499 QN=n1282 Q=regfile[11][10] D=n2274
+ CKN=clk_i__L3_N20
Xregfile_reg[11][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1316
+ SE=FE_OFN80_test_se_i RN=n4499 QN=n1283 Q=regfile[11][9] D=n2272
+ CKN=clk_i__L3_N20
Xregfile_reg[11][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n1508
+ SE=FE_OFN111_test_se_i RN=n4499 QN=n1284 Q=regfile[11][8] D=n2270
+ CKN=clk_i__L3_N20
Xregfile_reg[11][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n1476
+ SE=FE_OFN111_test_se_i RN=n4499 QN=n1285 Q=regfile[11][7] D=n2268
+ CKN=clk_i__L3_N21
Xregfile_reg[11][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1510
+ SE=FE_OFN78_test_se_i RN=n4499 QN=n1286 Q=regfile[11][6] D=n2266
+ CKN=clk_i__L3_N21
Xregfile_reg[11][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n1450
+ SE=FE_OFN90_test_se_i RN=n4499 QN=n1287 Q=regfile[11][5] D=n2264
+ CKN=clk_i__L3_N22
Xregfile_reg[11][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1416
+ SE=FE_OFN79_test_se_i RN=n4499 QN=n1288 Q=regfile[11][4] D=n2262
+ CKN=clk_i__L3_N22
Xregfile_reg[11][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1385
+ SE=FE_OFN90_test_se_i RN=n4500 QN=n1289 Q=regfile[11][3] D=n2260
+ CKN=clk_i__L3_N22
Xregfile_reg[11][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n1323
+ SE=FE_OFN11_test_se_i RN=n4500 QN=n1290 Q=regfile[11][2] D=n2258
+ CKN=clk_i__L3_N22
Xregfile_reg[11][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1483
+ SE=FE_OFN80_test_se_i RN=n4500 QN=n1291 Q=regfile[11][1] D=n2256
+ CKN=clk_i__L3_N22
Xregfile_reg[11][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1420
+ SE=FE_OFN115_test_se_i RN=n4500 QN=n1292 Q=regfile[11][0] D=n2254
+ CKN=clk_i__L3_N22
Xregfile_reg[7][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n1485
+ SE=FE_OFN56_test_se_i RN=n4505 QN=n1389 Q=regfile[7][31] D=n2060
+ CKN=clk_i__L3_N17
Xregfile_reg[7][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n1486
+ SE=FE_OFN57_test_se_i RN=n4505 QN=n1390 Q=regfile[7][30] D=n2058
+ CKN=clk_i__L3_N23
Xregfile_reg[7][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n1359
+ SE=FE_OFN74_test_se_i RN=n4505 QN=n1391 Q=regfile[7][29] D=n2056
+ CKN=clk_i__L3_N18
Xregfile_reg[7][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n1201
+ SE=FE_OFN58_test_se_i RN=n4505 QN=n1392 Q=regfile[7][28] D=n2054
+ CKN=clk_i__L3_N14
Xregfile_reg[7][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n1456
+ SE=FE_OFN58_test_se_i RN=n4505 QN=n1393 Q=regfile[7][27] D=n2052
+ CKN=clk_i__L3_N17
Xregfile_reg[7][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n1330
+ SE=FE_OFN74_test_se_i RN=n4505 QN=n1394 Q=regfile[7][26] D=n2050
+ CKN=clk_i__L3_N18
Xregfile_reg[7][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1152
+ SE=FE_OFN22_test_se_i RN=n4505 QN=n1395 Q=regfile[7][25] D=n2048
+ CKN=clk_i__L3_N18
Xregfile_reg[7][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1364
+ SE=FE_OFN11_test_se_i RN=n4505 QN=n1396 Q=regfile[7][24] D=n2046
+ CKN=clk_i__L3_N23
Xregfile_reg[7][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1342
+ SE=FE_OFN17_test_se_i RN=n4506 QN=n1397 Q=regfile[7][23] D=n2044
+ CKN=clk_i__L3_N5
Xregfile_reg[7][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1397
+ SE=FE_OFN17_test_se_i RN=n4506 QN=n1398 Q=regfile[7][22] D=n2042
+ CKN=clk_i__L3_N5
Xregfile_reg[7][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1306
+ SE=FE_OFN17_test_se_i RN=n4506 QN=n1399 Q=regfile[7][21] D=n2040
+ CKN=clk_i__L3_N4
Xregfile_reg[7][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1431
+ SE=FE_OFN64_test_se_i RN=n4506 QN=n1400 Q=regfile[7][20] D=n2038
+ CKN=clk_i__L3_N4
Xregfile_reg[7][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1775
+ SE=FE_OFN55_test_se_i RN=n4506 QN=n1401 Q=regfile[7][19] D=n2036
+ CKN=clk_i__L3_N3
Xregfile_reg[7][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1403
+ SE=FE_OFN65_test_se_i RN=n4506 QN=n1402 Q=regfile[7][18] D=n2034
+ CKN=clk_i__L3_N3
Xregfile_reg[7][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1465
+ SE=FE_OFN55_test_se_i RN=n4506 QN=n1403 Q=regfile[7][17] D=n2032
+ CKN=clk_i__L3_N3
Xregfile_reg[7][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n1467
+ SE=FE_OFN54_test_se_i RN=n4506 QN=n1404 Q=regfile[7][16] D=n2030
+ CKN=clk_i__L3_N3
Xregfile_reg[7][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1437
+ SE=FE_OFN1_test_se_i RN=n4506 QN=n1405 Q=regfile[7][15] D=n2028
+ CKN=clk_i__L3_N18
Xregfile_reg[7][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1438
+ SE=FE_OFN76_test_se_i RN=n4506 QN=n1406 Q=regfile[7][14] D=n2026
+ CKN=clk_i__L3_N19
Xregfile_reg[7][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1439
+ SE=FE_OFN4_test_se_i RN=n4506 QN=n1407 Q=regfile[7][13] D=n2024
+ CKN=clk_i__L3_N18
Xregfile_reg[7][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n1504
+ SE=FE_OFN4_test_se_i RN=n4506 QN=n1408 Q=regfile[7][12] D=n2022
+ CKN=clk_i__L3_N19
Xregfile_reg[7][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1441
+ SE=FE_OFN56_test_se_i RN=n4506 QN=n1409 Q=regfile[7][11] D=n2020
+ CKN=clk_i__L3_N17
Xregfile_reg[7][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1506
+ SE=FE_OFN3_test_se_i RN=n4506 QN=n1410 Q=regfile[7][10] D=n2018
+ CKN=clk_i__L3_N20
Xregfile_reg[7][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n1507
+ SE=FE_OFN114_test_se_i RN=n4506 QN=n1411 Q=regfile[7][9] D=n2016
+ CKN=clk_i__L3_N20
Xregfile_reg[7][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1315
+ SE=FE_OFN111_test_se_i RN=n4506 QN=n1412 Q=regfile[7][8] D=n2014
+ CKN=clk_i__L3_N20
Xregfile_reg[7][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1509
+ SE=FE_OFN78_test_se_i RN=n4506 QN=n1413 Q=regfile[7][7] D=n2012
+ CKN=clk_i__L3_N21
Xregfile_reg[7][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1413
+ SE=FE_OFN78_test_se_i RN=n4506 QN=n1414 Q=regfile[7][6] D=n2010
+ CKN=clk_i__L3_N21
Xregfile_reg[7][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1349
+ SE=FE_OFN78_test_se_i RN=n4509 QN=n1415 Q=regfile[7][5] D=n2008
+ CKN=clk_i__L3_N21
Xregfile_reg[7][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1417
+ SE=FE_OFN79_test_se_i RN=n4509 QN=n1416 Q=regfile[7][4] D=n2006
+ CKN=clk_i__L3_N22
Xregfile_reg[7][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1482
+ SE=FE_OFN90_test_se_i RN=n4509 QN=n1417 Q=regfile[7][3] D=n2004
+ CKN=clk_i__L3_N22
Xregfile_reg[7][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n1387
+ SE=FE_OFN80_test_se_i RN=n4509 QN=n1418 Q=regfile[7][2] D=n2002
+ CKN=clk_i__L3_N22
Xregfile_reg[7][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n1451
+ SE=FE_OFN80_test_se_i RN=n4509 QN=n1419 Q=regfile[7][1] D=n2000
+ CKN=clk_i__L3_N20
Xregfile_reg[7][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1516
+ SE=FE_OFN115_test_se_i RN=n4509 QN=n1420 Q=regfile[7][0] D=n1998
+ CKN=clk_i__L3_N22
Xregfile_reg[29][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n717
+ SE=FE_OFN72_test_se_i RN=n4466 QN=n685 Q=regfile[29][31] D=n3468
+ CKN=clk_i__L3_N27
Xregfile_reg[29][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n689
+ SE=FE_OFN18_test_se_i RN=n4466 QN=n686 Q=regfile[29][30] D=n3466
+ CKN=clk_i__L3_N27
Xregfile_reg[29][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n703
+ SE=FE_OFN73_test_se_i RN=n4466 QN=n687 Q=regfile[29][29] D=n3464
+ CKN=clk_i__L3_N13
Xregfile_reg[29][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n722
+ SE=FE_OFN73_test_se_i RN=n4466 QN=n688 Q=regfile[29][28] D=n3462
+ CKN=clk_i__L3_N13
Xregfile_reg[29][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n690
+ SE=FE_OFN18_test_se_i RN=n4466 QN=n689 Q=regfile[29][27] D=n3460
+ CKN=clk_i__L3_N13
Xregfile_reg[29][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n687
+ SE=FE_OFN73_test_se_i RN=n4466 QN=n690 Q=regfile[29][26] D=n3458
+ CKN=clk_i__L3_N13
Xregfile_reg[29][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n702
+ SE=FE_OFN102_test_se_i RN=n4466 QN=n691 Q=regfile[29][25] D=n3456
+ CKN=clk_i__L3_N15
Xregfile_reg[29][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n724
+ SE=FE_OFN72_test_se_i RN=n4466 QN=n692 Q=regfile[29][24] D=n3454
+ CKN=clk_i__L3_N27
Xregfile_reg[29][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n694
+ SE=FE_OFN100_test_se_i RN=n4466 QN=n693 Q=regfile[29][23] D=n3452
+ CKN=clk_i__L3_N2
Xregfile_reg[29][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n726
+ SE=FE_OFN100_test_se_i RN=n4466 QN=n694 Q=regfile[29][22] D=n3450
+ CKN=clk_i__L3_N2
Xregfile_reg[29][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n731
+ SE=FE_OFN68_test_se_i RN=n4467 QN=n695 Q=regfile[29][21] D=n3448
+ CKN=clk_i__L3_N2
Xregfile_reg[29][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n695
+ SE=FE_OFN68_test_se_i RN=n4467 QN=n696 Q=regfile[29][20] D=n3446
+ CKN=clk_i__L3_N1
Xregfile_reg[29][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n988
+ SE=FE_OFN68_test_se_i RN=n4467 QN=n697 Q=regfile[29][19] D=n3444
+ CKN=clk_i__L3_N1
Xregfile_reg[29][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n697
+ SE=FE_OFN68_test_se_i RN=n4467 QN=n698 Q=regfile[29][18] D=n3442
+ CKN=clk_i__L3_N1
Xregfile_reg[29][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n664
+ SE=FE_OFN68_test_se_i RN=n4467 QN=n699 Q=regfile[29][17] D=n3440
+ CKN=clk_i__L3_N1
Xregfile_reg[29][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n699
+ SE=FE_OFN68_test_se_i RN=n4467 QN=n700 Q=regfile[29][16] D=n3438
+ CKN=clk_i__L3_N2
Xregfile_reg[29][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n958
+ SE=FE_OFN100_test_se_i RN=n4467 QN=n701 Q=regfile[29][15] D=n3436
+ CKN=clk_i__L3_N2
Xregfile_reg[29][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n669
+ SE=FE_OFN99_test_se_i RN=n4467 QN=n702 Q=regfile[29][14] D=n3434
+ CKN=clk_i__L3_N15
Xregfile_reg[29][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n704
+ SE=FE_OFN102_test_se_i RN=n4467 QN=n703 Q=regfile[29][13] D=n3432
+ CKN=clk_i__L3_N13
Xregfile_reg[29][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n672
+ SE=FE_OFN102_test_se_i RN=n4467 QN=n704 Q=regfile[29][12] D=n3430
+ CKN=clk_i__L3_N13
Xregfile_reg[29][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n684
+ SE=FE_OFN83_test_se_i RN=n4467 QN=n705 Q=regfile[29][11] D=n3428
+ CKN=clk_i__L3_N26
Xregfile_reg[29][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n962
+ SE=FE_OFN83_test_se_i RN=n4467 QN=n706 Q=regfile[29][10] D=n3426
+ CKN=clk_i__L3_N27
Xregfile_reg[29][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n740
+ SE=FE_OFN106_test_se_i RN=n4467 QN=n707 Q=regfile[29][9] D=n3424
+ CKN=clk_i__L3_N26
Xregfile_reg[29][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n996
+ SE=FE_OFN20_test_se_i RN=n4467 QN=n708 Q=regfile[29][8] D=n3422
+ CKN=clk_i__L3_N26
Xregfile_reg[29][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n997
+ SE=FE_OFN89_test_se_i RN=n4467 QN=n709 Q=regfile[29][7] D=n3420
+ CKN=clk_i__L3_N7
Xregfile_reg[29][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n711
+ SE=FE_OFN89_test_se_i RN=n4467 QN=n710 Q=regfile[29][6] D=n3418
+ CKN=clk_i__L3_N7
Xregfile_reg[29][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n743
+ SE=FE_OFN89_test_se_i RN=n4467 QN=n711 Q=regfile[29][5] D=n3416
+ CKN=clk_i__L3_N7
Xregfile_reg[29][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n742
+ SE=FE_OFN89_test_se_i RN=n4467 QN=n712 Q=regfile[29][4] D=n3414
+ CKN=clk_i__L3_N7
Xregfile_reg[29][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n708
+ SE=FE_OFN20_test_se_i RN=n4468 QN=n713 Q=regfile[29][3] D=n3412
+ CKN=clk_i__L3_N26
Xregfile_reg[29][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n24
+ SE=FE_OFN20_test_se_i RN=n4468 QN=n714 Q=regfile[29][2] D=n3410
+ CKN=clk_i__L3_N26
Xregfile_reg[29][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n747
+ SE=FE_OFN106_test_se_i RN=n4468 QN=n715 Q=regfile[29][1] D=n3408
+ CKN=clk_i__L3_N26
Xregfile_reg[29][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n961
+ SE=FE_OFN83_test_se_i RN=n4468 QN=n716 Q=regfile[29][0] D=n3406
+ CKN=clk_i__L3_N26
Xregfile_reg[25][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n834
+ SE=FE_OFN81_test_se_i RN=n4473 QN=n813 Q=regfile[25][31] D=n3212
+ CKN=clk_i__L3_N6
Xregfile_reg[25][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n782
+ SE=FE_OFN81_test_se_i RN=n4473 QN=n814 Q=regfile[25][30] D=n3210
+ CKN=clk_i__L3_N12
Xregfile_reg[25][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n832
+ SE=FE_OFN71_test_se_i RN=FE_OFN156_n4473 QN=n815 Q=regfile[25][29] D=n3208
+ CKN=clk_i__L3_N14
Xregfile_reg[25][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n817
+ SE=FE_OFN92_test_se_i RN=FE_OFN156_n4473 QN=n816 Q=regfile[25][28] D=n3206
+ CKN=clk_i__L3_N14
Xregfile_reg[25][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1105
+ SE=FE_OFN92_test_se_i RN=FE_OFN156_n4473 QN=n817 Q=regfile[25][27] D=n3204
+ CKN=clk_i__L3_N12
Xregfile_reg[25][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n752
+ SE=FE_OFN92_test_se_i RN=FE_OFN156_n4473 QN=n818 Q=regfile[25][26] D=n3202
+ CKN=clk_i__L3_N12
Xregfile_reg[25][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n848
+ SE=FE_OFN75_test_se_i RN=FE_OFN156_n4473 QN=n819 Q=regfile[25][25] D=n3200
+ CKN=clk_i__L3_N12
Xregfile_reg[25][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n781
+ SE=FE_OFN81_test_se_i RN=n4473 QN=n820 Q=regfile[25][24] D=n3198
+ CKN=clk_i__L3_N6
Xregfile_reg[25][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n822
+ SE=FE_OFN60_test_se_i RN=FE_OFN154_n4476 QN=n821 Q=regfile[25][23] D=n3196
+ CKN=clk
Xregfile_reg[25][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n854
+ SE=FE_OFN60_test_se_i RN=FE_OFN154_n4476 QN=n822 Q=regfile[25][22] D=n3194
+ CKN=clk
Xregfile_reg[25][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1018
+ SE=FE_OFN62_test_se_i RN=FE_OFN154_n4476 QN=n823 Q=regfile[25][21] D=n3192
+ CKN=clk
Xregfile_reg[25][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n827
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n824 Q=regfile[25][20] D=n3190
+ CKN=clk_i__L3_N4
Xregfile_reg[25][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n762
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n825 Q=regfile[25][19] D=n3188
+ CKN=clk_i__L3_N4
Xregfile_reg[25][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n792
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n826 Q=regfile[25][18] D=n3186
+ CKN=clk
Xregfile_reg[25][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n859
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n827 Q=regfile[25][17] D=n3184
+ CKN=clk_i__L3_N5
Xregfile_reg[25][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n760
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n828 Q=regfile[25][16] D=n3182
+ CKN=clk_i__L3_N4
Xregfile_reg[25][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n765
+ SE=FE_OFN77_test_se_i RN=FE_OFN154_n4476 QN=n829 Q=regfile[25][15] D=n3180
+ CKN=clk_i__L3_N15
Xregfile_reg[25][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n862
+ SE=FE_OFN70_test_se_i RN=FE_OFN154_n4476 QN=n830 Q=regfile[25][14] D=n3178
+ CKN=clk_i__L3_N5
Xregfile_reg[25][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n851
+ SE=FE_OFN77_test_se_i RN=FE_OFN154_n4476 QN=n831 Q=regfile[25][13] D=n3176
+ CKN=clk_i__L3_N15
Xregfile_reg[25][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n831
+ SE=FE_OFN71_test_se_i RN=FE_OFN154_n4476 QN=n832 Q=regfile[25][12] D=n3174
+ CKN=clk_i__L3_N15
Xregfile_reg[25][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n780
+ SE=FE_OFN84_test_se_i RN=n4476 QN=n833 Q=regfile[25][11] D=n3172
+ CKN=clk_i__L3_N6
Xregfile_reg[25][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n802
+ SE=FE_OFN81_test_se_i RN=n4476 QN=n834 Q=regfile[25][10] D=n3170
+ CKN=clk_i__L3_N6
Xregfile_reg[25][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n867
+ SE=FE_OFN84_test_se_i RN=n4476 QN=n835 Q=regfile[25][9] D=n3168
+ CKN=clk_i__L3_N6
Xregfile_reg[25][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n868
+ SE=FE_OFN113_test_se_i RN=n4476 QN=n836 Q=regfile[25][8] D=n3166
+ CKN=clk_i__L3_N6
Xregfile_reg[25][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1125
+ SE=FE_OFN0_test_se_i RN=n4476 QN=n837 Q=regfile[25][7] D=n3164 CKN=clk_i__L3_N8
Xregfile_reg[25][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n869
+ SE=FE_OFN0_test_se_i RN=n4476 QN=n838 Q=regfile[25][6] D=n3162 CKN=clk_i__L3_N8
Xregfile_reg[25][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n838
+ SE=FE_OFN0_test_se_i RN=n4475 QN=n839 Q=regfile[25][5] D=n3160 CKN=clk_i__L3_N8
Xregfile_reg[25][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n1095
+ SE=FE_OFN112_test_se_i RN=n4475 QN=n840 Q=regfile[25][4] D=n3158
+ CKN=clk_i__L3_N8
Xregfile_reg[25][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n1097
+ SE=FE_OFN0_test_se_i RN=n4475 QN=n841 Q=regfile[25][3] D=n3156 CKN=clk_i__L3_N8
Xregfile_reg[25][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n1130
+ SE=FE_OFN91_test_se_i RN=n4475 QN=n842 Q=regfile[25][2] D=n3154
+ CKN=clk_i__L3_N8
Xregfile_reg[25][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n779
+ SE=FE_OFN84_test_se_i RN=n4475 QN=n843 Q=regfile[25][1] D=n3152
+ CKN=clk_i__L3_N6
Xregfile_reg[25][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1132
+ SE=FE_OFN85_test_se_i RN=n4475 QN=n844 Q=regfile[25][0] D=n3150
+ CKN=clk_i__L3_N6
Xregfile_reg[21][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n909
+ SE=FE_OFN72_test_se_i RN=n4480 QN=n941 Q=regfile[21][31] D=n2956
+ CKN=clk_i__L3_N12
Xregfile_reg[21][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n974
+ SE=FE_OFN72_test_se_i RN=n4480 QN=n942 Q=regfile[21][30] D=n2954
+ CKN=clk_i__L3_N12
Xregfile_reg[21][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n879
+ SE=FE_OFN18_test_se_i RN=FE_OFN152_n4480 QN=n943 Q=regfile[21][29] D=n2952
+ CKN=clk_i__L3_N13
Xregfile_reg[21][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n912
+ SE=FE_OFN18_test_se_i RN=FE_OFN152_n4480 QN=n944 Q=regfile[21][28] D=n2950
+ CKN=clk_i__L3_N12
Xregfile_reg[21][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n721
+ SE=FE_OFN18_test_se_i RN=n4480 QN=n945 Q=regfile[21][27] D=n2948
+ CKN=clk_i__L3_N12
Xregfile_reg[21][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n976
+ SE=FE_OFN18_test_se_i RN=FE_OFN152_n4480 QN=n946 Q=regfile[21][26] D=n2946
+ CKN=clk_i__L3_N13
Xregfile_reg[21][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n915
+ SE=FE_OFN99_test_se_i RN=FE_OFN151_n4481 QN=n947 Q=regfile[21][25] D=n2944
+ CKN=clk_i__L3_N15
Xregfile_reg[21][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n884
+ SE=FE_OFN72_test_se_i RN=FE_OFN151_n4481 QN=n948 Q=regfile[21][24] D=n2942
+ CKN=clk_i__L3_N27
Xregfile_reg[21][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n732
+ SE=FE_OFN100_test_se_i RN=FE_OFN151_n4481 QN=n949 Q=regfile[21][23] D=n2940
+ CKN=clk
Xregfile_reg[21][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n982
+ SE=FE_OFN100_test_se_i RN=FE_OFN151_n4481 QN=n950 Q=regfile[21][22] D=n2938
+ CKN=clk
Xregfile_reg[21][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n889
+ SE=FE_OFN67_test_se_i RN=FE_OFN151_n4481 QN=n951 Q=regfile[21][21] D=n2936
+ CKN=clk_i__L3_N1
Xregfile_reg[21][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n920
+ SE=FE_OFN60_test_se_i RN=FE_OFN151_n4481 QN=n952 Q=regfile[21][20] D=n2934
+ CKN=clk_i__L3_N1
Xregfile_reg[21][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n986
+ SE=FE_OFN67_test_se_i RN=FE_OFN151_n4481 QN=n953 Q=regfile[21][19] D=n2932
+ CKN=clk_i__L3_N1
Xregfile_reg[21][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n983
+ SE=FE_OFN67_test_se_i RN=FE_OFN151_n4481 QN=n954 Q=regfile[21][18] D=n2930
+ CKN=clk_i__L3_N1
Xregfile_reg[21][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n890
+ SE=FE_OFN67_test_se_i RN=FE_OFN151_n4481 QN=n955 Q=regfile[21][17] D=n2928
+ CKN=clk_i__L3_N1
Xregfile_reg[21][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n987
+ SE=FE_OFN67_test_se_i RN=FE_OFN151_n4481 QN=n956 Q=regfile[21][16] D=n2926
+ CKN=clk_i__L3_N1
Xregfile_reg[21][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n693
+ SE=FE_OFN100_test_se_i RN=FE_OFN151_n4481 QN=n957 Q=regfile[21][15] D=n2924
+ CKN=clk_i__L3_N15
Xregfile_reg[21][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n957
+ SE=FE_OFN100_test_se_i RN=FE_OFN151_n4481 QN=n958 Q=regfile[21][14] D=n2922
+ CKN=clk_i__L3_N15
Xregfile_reg[21][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n691
+ SE=FE_OFN102_test_se_i RN=FE_OFN151_n4481 QN=n959 Q=regfile[21][13] D=n2920
+ CKN=clk_i__L3_N15
Xregfile_reg[21][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n895
+ SE=FE_OFN102_test_se_i RN=FE_OFN151_n4481 QN=n960 Q=regfile[21][12] D=n2918
+ CKN=clk_i__L3_N15
Xregfile_reg[21][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n673
+ SE=FE_OFN83_test_se_i RN=n4481 QN=n961 Q=regfile[21][11] D=n2916
+ CKN=clk_i__L3_N26
Xregfile_reg[21][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n738
+ SE=FE_OFN83_test_se_i RN=n4481 QN=n962 Q=regfile[21][10] D=n2914
+ CKN=clk_i__L3_N27
Xregfile_reg[21][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n907
+ SE=FE_OFN88_test_se_i RN=n4481 QN=n963 Q=regfile[21][9] D=n2912
+ CKN=clk_i__L3_N26
Xregfile_reg[21][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n970
+ SE=FE_OFN88_test_se_i RN=n4481 QN=n964 Q=regfile[21][8] D=n2910
+ CKN=clk_i__L3_N26
Xregfile_reg[21][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n966
+ SE=FE_OFN87_test_se_i RN=n4482 QN=n965 Q=regfile[21][7] D=n2908
+ CKN=clk_i__L3_N7
Xregfile_reg[21][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n936
+ SE=FE_OFN87_test_se_i RN=n4482 QN=n966 Q=regfile[21][6] D=n2906
+ CKN=clk_i__L3_N7
Xregfile_reg[21][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n999
+ SE=FE_OFN9_test_se_i RN=n4482 QN=n967 Q=regfile[21][5] D=n2904 CKN=clk_i__L3_N7
Xregfile_reg[21][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n903
+ SE=FE_OFN9_test_se_i RN=n4482 QN=n968 Q=regfile[21][4] D=n2902 CKN=clk_i__L3_N7
Xregfile_reg[21][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n937
+ SE=FE_OFN87_test_se_i RN=n4482 QN=n969 Q=regfile[21][3] D=n2900
+ CKN=clk_i__L3_N7
Xregfile_reg[21][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n1002
+ SE=FE_OFN88_test_se_i RN=n4482 QN=n970 Q=regfile[21][2] D=n2898
+ CKN=clk_i__L3_N26
Xregfile_reg[21][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1025
+ SE=FE_OFN85_test_se_i RN=n4482 QN=n971 Q=regfile[21][1] D=n2896
+ CKN=clk_i__L3_N6
Xregfile_reg[21][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n908
+ SE=FE_OFN86_test_se_i RN=n4482 QN=n972 Q=regfile[21][0] D=n2894
+ CKN=clk_i__L3_N6
Xregfile_reg[17][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n1070
+ SE=FE_OFN82_test_se_i RN=n4488 QN=n1069 Q=regfile[17][31] D=n2700
+ CKN=clk_i__L3_N12
Xregfile_reg[17][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n1006
+ SE=FE_OFN82_test_se_i RN=FE_OFN150_n4488 QN=n1070 Q=regfile[17][30] D=n2698
+ CKN=clk_i__L3_N12
Xregfile_reg[17][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n850
+ SE=FE_OFN75_test_se_i RN=FE_OFN150_n4488 QN=n1071 Q=regfile[17][29] D=n2696
+ CKN=clk_i__L3_N12
Xregfile_reg[17][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1007
+ SE=FE_OFN75_test_se_i RN=FE_OFN150_n4488 QN=n1072 Q=regfile[17][28] D=n2694
+ CKN=clk_i__L3_N12
Xregfile_reg[17][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1008
+ SE=FE_OFN75_test_se_i RN=FE_OFN150_n4488 QN=n1073 Q=regfile[17][27] D=n2692
+ CKN=clk_i__L3_N12
Xregfile_reg[17][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1071
+ SE=FE_OFN75_test_se_i RN=FE_OFN150_n4488 QN=n1074 Q=regfile[17][26] D=n2690
+ CKN=clk_i__L3_N12
Xregfile_reg[17][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n1011
+ SE=FE_OFN77_test_se_i RN=FE_OFN150_n4488 QN=n1075 Q=regfile[17][25] D=n2688
+ CKN=clk_i__L3_N15
Xregfile_reg[17][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n1089
+ SE=FE_OFN82_test_se_i RN=n4488 QN=n1076 Q=regfile[17][24] D=n2686
+ CKN=clk_i__L3_N6
Xregfile_reg[17][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n917
+ SE=FE_OFN61_test_se_i RN=FE_OFN150_n4488 QN=n1077 Q=regfile[17][23] D=n2684
+ CKN=clk
Xregfile_reg[17][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n1014
+ SE=FE_OFN60_test_se_i RN=FE_OFN150_n4488 QN=n1078 Q=regfile[17][22] D=n2682
+ CKN=clk
Xregfile_reg[17][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1080
+ SE=FE_OFN62_test_se_i RN=FE_OFN150_n4488 QN=n1079 Q=regfile[17][21] D=n2680
+ CKN=clk_i__L3_N1
Xregfile_reg[17][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1112
+ SE=FE_OFN62_test_se_i RN=FE_OFN150_n4488 QN=n1080 Q=regfile[17][20] D=n2678
+ CKN=clk_i__L3_N1
Xregfile_reg[17][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n1084
+ SE=FE_OFN62_test_se_i RN=FE_OFN150_n4488 QN=n1081 Q=regfile[17][19] D=n2676
+ CKN=clk
Xregfile_reg[17][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n1114
+ SE=FE_OFN62_test_se_i RN=FE_OFN150_n4488 QN=n1082 Q=regfile[17][18] D=n2674
+ CKN=clk_i__L3_N1
Xregfile_reg[17][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n1082
+ SE=FE_OFN62_test_se_i RN=FE_OFN150_n4488 QN=n1083 Q=regfile[17][17] D=n2672
+ CKN=clk_i__L3_N1
Xregfile_reg[17][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n1083
+ SE=FE_OFN62_test_se_i RN=FE_OFN150_n4488 QN=n1084 Q=regfile[17][16] D=n2670
+ CKN=clk
Xregfile_reg[17][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n829
+ SE=FE_OFN77_test_se_i RN=FE_OFN150_n4488 QN=n1085 Q=regfile[17][15] D=n2668
+ CKN=clk_i__L3_N15
Xregfile_reg[17][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n1085
+ SE=FE_OFN77_test_se_i RN=FE_OFN150_n4488 QN=n1086 Q=regfile[17][14] D=n2666
+ CKN=clk_i__L3_N15
Xregfile_reg[17][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1107
+ SE=FE_OFN77_test_se_i RN=FE_OFN150_n4488 QN=n1087 Q=regfile[17][13] D=n2664
+ CKN=clk_i__L3_N15
Xregfile_reg[17][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n1087
+ SE=FE_OFN77_test_se_i RN=FE_OFN150_n4488 QN=n1088 Q=regfile[17][12] D=n2662
+ CKN=clk_i__L3_N15
Xregfile_reg[17][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1090
+ SE=FE_OFN86_test_se_i RN=n4488 QN=n1089 Q=regfile[17][11] D=n2660
+ CKN=clk_i__L3_N6
Xregfile_reg[17][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n1122
+ SE=FE_OFN86_test_se_i RN=n4488 QN=n1090 Q=regfile[17][10] D=n2658
+ CKN=clk_i__L3_N6
Xregfile_reg[17][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n804
+ SE=FE_OFN113_test_se_i RN=n4489 QN=n1091 Q=regfile[17][9] D=n2656
+ CKN=clk_i__L3_N6
Xregfile_reg[17][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1027
+ SE=FE_OFN113_test_se_i RN=n4489 QN=n1092 Q=regfile[17][8] D=n2654
+ CKN=clk_i__L3_N6
Xregfile_reg[17][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n837
+ SE=FE_OFN0_test_se_i RN=n4489 QN=n1093 Q=regfile[17][7] D=n2652
+ CKN=clk_i__L3_N8
Xregfile_reg[17][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1126
+ SE=FE_OFN112_test_se_i RN=n4489 QN=n1094 Q=regfile[17][6] D=n2650
+ CKN=clk_i__L3_N8
Xregfile_reg[17][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n1063
+ SE=FE_OFN112_test_se_i RN=n4489 QN=n1095 Q=regfile[17][5] D=n2648
+ CKN=clk_i__L3_N8
Xregfile_reg[17][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n1094
+ SE=FE_OFN112_test_se_i RN=n4489 QN=n1096 Q=regfile[17][4] D=n2646
+ CKN=clk_i__L3_N8
Xregfile_reg[17][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1028
+ SE=FE_OFN113_test_se_i RN=n4489 QN=n1097 Q=regfile[17][3] D=n2644
+ CKN=clk_i__L3_N8
Xregfile_reg[17][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n1034
+ SE=FE_OFN113_test_se_i RN=n4489 QN=n1098 Q=regfile[17][2] D=n2642
+ CKN=clk_i__L3_N8
Xregfile_reg[17][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1036
+ SE=FE_OFN85_test_se_i RN=n4489 QN=n1099 Q=regfile[17][1] D=n2640
+ CKN=clk_i__L3_N6
Xregfile_reg[17][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n876
+ SE=FE_OFN85_test_se_i RN=n4489 QN=n1100 Q=regfile[17][0] D=n2638
+ CKN=clk_i__L3_N6
Xregfile_reg[13][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n1422
+ SE=FE_OFN81_test_se_i RN=n4494 QN=n1197 Q=regfile[13][31] D=n2444
+ CKN=clk_i__L3_N23
Xregfile_reg[13][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n1332
+ SE=FE_OFN57_test_se_i RN=n4494 QN=n1198 Q=regfile[13][30] D=n2442
+ CKN=clk_i__L3_N23
Xregfile_reg[13][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n800
+ SE=FE_OFN71_test_se_i RN=n4495 QN=n1199 Q=regfile[13][29] D=n2440
+ CKN=clk_i__L3_N14
Xregfile_reg[13][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n1169
+ SE=FE_OFN58_test_se_i RN=n4495 QN=n1200 Q=regfile[13][28] D=n2438
+ CKN=clk_i__L3_N14
Xregfile_reg[13][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1200
+ SE=FE_OFN92_test_se_i RN=n4495 QN=n1201 Q=regfile[13][27] D=n2436
+ CKN=clk_i__L3_N23
Xregfile_reg[13][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n1231
+ SE=FE_OFN58_test_se_i RN=n4495 QN=n1202 Q=regfile[13][26] D=n2434
+ CKN=clk_i__L3_N14
Xregfile_reg[13][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n1235
+ SE=FE_OFN70_test_se_i RN=n4495 QN=n1203 Q=regfile[13][25] D=n2432
+ CKN=clk_i__L3_N14
Xregfile_reg[13][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n1229
+ SE=FE_OFN81_test_se_i RN=n4495 QN=n1204 Q=regfile[13][24] D=n2430
+ CKN=clk_i__L3_N23
Xregfile_reg[13][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n830
+ SE=FE_OFN70_test_se_i RN=n4495 QN=n1205 Q=regfile[13][23] D=n2428
+ CKN=clk_i__L3_N5
Xregfile_reg[13][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1302
+ SE=FE_OFN69_test_se_i RN=n4495 QN=n1206 Q=regfile[13][22] D=n2426
+ CKN=clk_i__L3_N5
Xregfile_reg[13][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1175
+ SE=FE_OFN66_test_se_i RN=n4495 QN=n1207 Q=regfile[13][21] D=n2424
+ CKN=clk_i__L3_N4
Xregfile_reg[13][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1240
+ SE=FE_OFN63_test_se_i RN=n4495 QN=n1208 Q=regfile[13][20] D=n2422
+ CKN=clk_i__L3_N4
Xregfile_reg[13][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1239
+ SE=FE_OFN66_test_se_i RN=n4495 QN=n1209 Q=regfile[13][19] D=n2420
+ CKN=clk_i__L3_N4
Xregfile_reg[13][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1212
+ SE=FE_OFN64_test_se_i RN=n4495 QN=n1210 Q=regfile[13][18] D=n2418
+ CKN=clk_i__L3_N5
Xregfile_reg[13][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1241
+ SE=FE_OFN17_test_se_i RN=n4495 QN=n1211 Q=regfile[13][17] D=n2416
+ CKN=clk_i__L3_N4
Xregfile_reg[13][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n1494
+ SE=FE_OFN63_test_se_i RN=n4495 QN=n1212 Q=regfile[13][16] D=n2414
+ CKN=clk_i__L3_N5
Xregfile_reg[13][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1149
+ SE=FE_OFN69_test_se_i RN=n4495 QN=n1213 Q=regfile[13][15] D=n2412
+ CKN=clk_i__L3_N18
Xregfile_reg[13][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n1462
+ SE=FE_OFN17_test_se_i RN=n4495 QN=n1214 Q=regfile[13][14] D=n2410
+ CKN=clk_i__L3_N5
Xregfile_reg[13][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1459
+ SE=FE_OFN22_test_se_i RN=n4495 QN=n1215 Q=regfile[13][13] D=n2408
+ CKN=clk_i__L3_N18
Xregfile_reg[13][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1427
+ SE=FE_OFN74_test_se_i RN=n4495 QN=n1216 Q=regfile[13][12] D=n2406
+ CKN=clk_i__L3_N18
Xregfile_reg[13][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1378
+ SE=FE_OFN115_test_se_i RN=n4496 QN=n1217 Q=regfile[13][11] D=n2404
+ CKN=clk_i__L3_N20
Xregfile_reg[13][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n1154
+ SE=FE_OFN115_test_se_i RN=n4496 QN=n1218 Q=regfile[13][10] D=n2402
+ CKN=clk_i__L3_N23
Xregfile_reg[13][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n1419
+ SE=FE_OFN80_test_se_i RN=n4496 QN=n1219 Q=regfile[13][9] D=n2400
+ CKN=clk_i__L3_N20
Xregfile_reg[13][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n1156
+ SE=FE_OFN80_test_se_i RN=n4496 QN=n1220 Q=regfile[13][8] D=n2398
+ CKN=clk_i__L3_N20
Xregfile_reg[13][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1223
+ SE=FE_OFN79_test_se_i RN=n4496 QN=n1221 Q=regfile[13][7] D=n2396
+ CKN=clk_i__L3_N21
Xregfile_reg[13][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n1253
+ SE=FE_OFN79_test_se_i RN=n4496 QN=n1222 Q=regfile[13][6] D=n2394
+ CKN=clk_i__L3_N21
Xregfile_reg[13][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n1191
+ SE=FE_OFN79_test_se_i RN=n4496 QN=n1223 Q=regfile[13][5] D=n2392
+ CKN=clk_i__L3_N21
Xregfile_reg[13][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n1192
+ SE=FE_OFN12_test_se_i RN=n4496 QN=n1224 Q=regfile[13][4] D=n2390
+ CKN=clk_i__L3_N8
Xregfile_reg[13][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n774
+ SE=FE_OFN12_test_se_i RN=n4496 QN=n1225 Q=regfile[13][3] D=n2388
+ CKN=clk_i__L3_N8
Xregfile_reg[13][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1290
+ SE=FE_OFN11_test_se_i RN=n4496 QN=n1226 Q=regfile[13][2] D=n2386
+ CKN=clk_i__L3_N22
Xregfile_reg[13][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n1259
+ SE=FE_OFN84_test_se_i RN=n4496 QN=n1227 Q=regfile[13][1] D=n2384
+ CKN=clk_i__L3_N22
Xregfile_reg[13][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1292
+ SE=FE_OFN84_test_se_i RN=n4496 QN=n1228 Q=regfile[13][0] D=n2382
+ CKN=clk_i__L3_N22
Xregfile_reg[9][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1389
+ SE=FE_OFN56_test_se_i RN=n4502 QN=n1325 Q=regfile[9][31] D=n2188
+ CKN=clk_i__L3_N17
Xregfile_reg[9][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n1297
+ SE=FE_OFN57_test_se_i RN=n4502 QN=n1326 Q=regfile[9][30] D=n2186
+ CKN=clk_i__L3_N23
Xregfile_reg[9][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n1360
+ SE=FE_OFN74_test_se_i RN=n4502 QN=n1327 Q=regfile[9][29] D=n2184
+ CKN=clk_i__L3_N18
Xregfile_reg[9][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1296
+ SE=FE_OFN58_test_se_i RN=n4502 QN=n1328 Q=regfile[9][28] D=n2182
+ CKN=clk_i__L3_N14
Xregfile_reg[9][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n1325
+ SE=FE_OFN57_test_se_i RN=n4502 QN=n1329 Q=regfile[9][27] D=n2180
+ CKN=clk_i__L3_N17
Xregfile_reg[9][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n1487
+ SE=FE_OFN58_test_se_i RN=n4502 QN=n1330 Q=regfile[9][26] D=n2178
+ CKN=clk_i__L3_N18
Xregfile_reg[9][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n1267
+ SE=FE_OFN69_test_se_i RN=n4502 QN=n1331 Q=regfile[9][25] D=n2176
+ CKN=clk_i__L3_N14
Xregfile_reg[9][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n1428
+ SE=FE_OFN81_test_se_i RN=n4502 QN=n1332 Q=regfile[9][24] D=n2174
+ CKN=clk_i__L3_N23
Xregfile_reg[9][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n1432
+ SE=FE_OFN64_test_se_i RN=n4502 QN=n1333 Q=regfile[9][23] D=n2172
+ CKN=clk_i__L3_N5
Xregfile_reg[9][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1270
+ SE=FE_OFN69_test_se_i RN=n4502 QN=n1334 Q=regfile[9][22] D=n2170
+ CKN=clk_i__L3_N5
Xregfile_reg[9][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n1209
+ SE=FE_OFN66_test_se_i RN=n4502 QN=n1335 Q=regfile[9][21] D=n2168
+ CKN=clk_i__L3_N4
Xregfile_reg[9][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1368
+ SE=FE_OFN66_test_se_i RN=n4502 QN=n1336 Q=regfile[9][20] D=n2166
+ CKN=clk_i__L3_N4
Xregfile_reg[9][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1369
+ SE=FE_OFN65_test_se_i RN=n4502 QN=n1337 Q=regfile[9][19] D=n2164
+ CKN=clk_i__L3_N4
Xregfile_reg[9][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1305
+ SE=FE_OFN65_test_se_i RN=n4502 QN=n1338 Q=regfile[9][18] D=n2162
+ CKN=clk_i__L3_N4
Xregfile_reg[9][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1371
+ SE=FE_OFN65_test_se_i RN=n4502 QN=n1339 Q=regfile[9][17] D=n2160
+ CKN=clk_i__L3_N4
Xregfile_reg[9][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1338
+ SE=FE_OFN65_test_se_i RN=n4502 QN=n1340 Q=regfile[9][16] D=n2158
+ CKN=clk_i__L3_N4
Xregfile_reg[9][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1150
+ SE=FE_OFN17_test_se_i RN=n4502 QN=n1341 Q=regfile[9][15] D=n2156
+ CKN=clk_i__L3_N18
Xregfile_reg[9][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1246
+ SE=FE_OFN76_test_se_i RN=n4502 QN=n1342 Q=regfile[9][14] D=n2154
+ CKN=clk_i__L3_N5
Xregfile_reg[9][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1376
+ SE=FE_OFN74_test_se_i RN=n4503 QN=n1343 Q=regfile[9][13] D=n2152
+ CKN=clk_i__L3_N18
Xregfile_reg[9][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1248
+ SE=FE_OFN74_test_se_i RN=n4503 QN=n1344 Q=regfile[9][12] D=n2150
+ CKN=clk_i__L3_N18
Xregfile_reg[9][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n1421
+ SE=FE_OFN57_test_se_i RN=n4503 QN=n1345 Q=regfile[9][11] D=n2148
+ CKN=clk_i__L3_N17
Xregfile_reg[9][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1186
+ SE=FE_OFN115_test_se_i RN=n4503 QN=n1346 Q=regfile[9][10] D=n2146
+ CKN=clk_i__L3_N20
Xregfile_reg[9][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n1411
+ SE=FE_OFN80_test_se_i RN=n4503 QN=n1347 Q=regfile[9][9] D=n2144
+ CKN=clk_i__L3_N20
Xregfile_reg[9][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n1319
+ SE=FE_OFN78_test_se_i RN=n4503 QN=n1348 Q=regfile[9][8] D=n2142
+ CKN=clk_i__L3_N22
Xregfile_reg[9][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n1317
+ SE=FE_OFN78_test_se_i RN=n4503 QN=n1349 Q=regfile[9][7] D=n2140
+ CKN=clk_i__L3_N21
Xregfile_reg[9][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1221
+ SE=FE_OFN79_test_se_i RN=n4503 QN=n1350 Q=regfile[9][6] D=n2138
+ CKN=clk_i__L3_N21
Xregfile_reg[9][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n1449
+ SE=FE_OFN90_test_se_i RN=n4503 QN=n1351 Q=regfile[9][5] D=n2136
+ CKN=clk_i__L3_N22
Xregfile_reg[9][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n1480
+ SE=FE_OFN12_test_se_i RN=n4503 QN=n1352 Q=regfile[9][4] D=n2134
+ CKN=clk_i__L3_N8
Xregfile_reg[9][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1384
+ SE=FE_OFN90_test_se_i RN=n4503 QN=n1353 Q=regfile[9][3] D=n2132
+ CKN=clk_i__L3_N22
Xregfile_reg[9][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n1258
+ SE=FE_OFN91_test_se_i RN=n4503 QN=n1354 Q=regfile[9][2] D=n2130
+ CKN=clk_i__L3_N22
Xregfile_reg[9][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1227
+ SE=FE_OFN84_test_se_i RN=n4503 QN=n1355 Q=regfile[9][1] D=n2128
+ CKN=clk_i__L3_N22
Xregfile_reg[9][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1196
+ SE=FE_OFN84_test_se_i RN=n4503 QN=n1356 Q=regfile[9][0] D=n2126
+ CKN=clk_i__L3_N22
Xregfile_reg[5][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n1425
+ SE=FE_OFN56_test_se_i RN=n4509 QN=n1453 Q=regfile[5][31] D=n1932
+ CKN=clk_i__L3_N17
Xregfile_reg[5][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n1230
+ SE=FE_OFN57_test_se_i RN=n4509 QN=n1454 Q=regfile[5][30] D=n1930
+ CKN=clk_i__L3_N23
Xregfile_reg[5][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n1394
+ SE=FE_OFN74_test_se_i RN=FE_OFN162_n4509 QN=n1455 Q=regfile[5][29] D=n1928
+ CKN=clk_i__L3_N18
Xregfile_reg[5][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1458
+ SE=FE_OFN58_test_se_i RN=FE_OFN162_n4509 QN=n1456 Q=regfile[5][28] D=n1926
+ CKN=clk_i__L3_N17
Xregfile_reg[5][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1361
+ SE=FE_OFN56_test_se_i RN=n4509 QN=n1457 Q=regfile[5][27] D=n1924
+ CKN=clk_i__L3_N17
Xregfile_reg[5][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1426
+ SE=FE_OFN56_test_se_i RN=FE_OFN162_n4509 QN=n1458 Q=regfile[5][26] D=n1922
+ CKN=clk_i__L3_N17
Xregfile_reg[5][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n1491
+ SE=FE_OFN74_test_se_i RN=FE_OFN162_n4509 QN=n1459 Q=regfile[5][25] D=n1920
+ CKN=clk_i__L3_N18
Xregfile_reg[5][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1492
+ SE=FE_OFN115_test_se_i RN=n4509 QN=n1460 Q=regfile[5][24] D=n1918
+ CKN=clk_i__L3_N23
Xregfile_reg[5][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n1365
+ SE=FE_OFN63_test_se_i RN=FE_OFN162_n4509 QN=n1461 Q=regfile[5][23] D=n1916
+ CKN=clk_i__L3_N5
Xregfile_reg[5][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n1366
+ SE=FE_OFN69_test_se_i RN=FE_OFN162_n4509 QN=n1462 Q=regfile[5][22] D=n1914
+ CKN=clk_i__L3_N5
Xregfile_reg[5][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n1177
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1463 Q=regfile[5][21] D=n1912
+ CKN=clk_i__L3_N4
Xregfile_reg[5][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1496
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1464 Q=regfile[5][20] D=n1910
+ CKN=clk_i__L3_N5
Xregfile_reg[5][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1435
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1465 Q=regfile[5][19] D=n1908
+ CKN=clk_i__L3_N3
Xregfile_reg[5][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1499
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1466 Q=regfile[5][18] D=n1906
+ CKN=clk_i__L3_N5
Xregfile_reg[5][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1498
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1467 Q=regfile[5][17] D=n1904
+ CKN=clk_i__L3_N3
Xregfile_reg[5][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1374
+ SE=FE_OFN17_test_se_i RN=FE_OFN162_n4509 QN=n1468 Q=regfile[5][16] D=n1902
+ CKN=clk_i__L3_N3
Xregfile_reg[5][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1181
+ SE=FE_OFN1_test_se_i RN=n4512 QN=n1469 Q=regfile[5][15] D=n1900
+ CKN=clk_i__L3_N18
Xregfile_reg[5][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1405
+ SE=FE_OFN1_test_se_i RN=n4512 QN=n1470 Q=regfile[5][14] D=n1898
+ CKN=clk_i__L3_N19
Xregfile_reg[5][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1503
+ SE=FE_OFN7_test_se_i RN=n4512 QN=n1471 Q=regfile[5][13] D=n1896
+ CKN=clk_i__L3_N18
Xregfile_reg[5][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1519
+ SE=FE_OFN4_test_se_i RN=n4512 QN=n1472 Q=regfile[5][12] D=n1894
+ CKN=clk_i__L3_N18
Xregfile_reg[5][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n1377
+ SE=FE_OFN56_test_se_i RN=n4512 QN=n1473 Q=regfile[5][11] D=n1892
+ CKN=clk_i__L3_N17
Xregfile_reg[5][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1282
+ SE=FE_OFN114_test_se_i RN=FE_OFN161_n4512 QN=n1474 Q=regfile[5][10] D=n1890
+ CKN=clk_i__L3_N20
Xregfile_reg[5][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1314
+ SE=FE_OFN114_test_se_i RN=n4512 QN=n1475 Q=regfile[5][9] D=n1888
+ CKN=clk_i__L3_N20
Xregfile_reg[5][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n1284
+ SE=FE_OFN111_test_se_i RN=FE_OFN161_n4512 QN=n1476 Q=regfile[5][8] D=n1886
+ CKN=clk_i__L3_N21
Xregfile_reg[5][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1381
+ SE=FE_OFN78_test_se_i RN=FE_OFN161_n4512 QN=n1477 Q=regfile[5][7] D=n1884
+ CKN=clk_i__L3_N21
Xregfile_reg[5][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1318
+ SE=FE_OFN12_test_se_i RN=FE_OFN161_n4512 QN=n1478 Q=regfile[5][6] D=n1882
+ CKN=clk_i__L3_N21
Xregfile_reg[5][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n1382
+ SE=FE_OFN79_test_se_i RN=FE_OFN161_n4512 QN=n1479 Q=regfile[5][5] D=n1880
+ CKN=clk_i__L3_N21
Xregfile_reg[5][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n1157
+ SE=FE_OFN79_test_se_i RN=FE_OFN161_n4512 QN=n1480 Q=regfile[5][4] D=n1878
+ CKN=clk_i__L3_N21
Xregfile_reg[5][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1383
+ SE=FE_OFN80_test_se_i RN=FE_OFN161_n4512 QN=n1481 Q=regfile[5][3] D=n1876
+ CKN=clk_i__L3_N22
Xregfile_reg[5][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n1386
+ SE=FE_OFN90_test_se_i RN=FE_OFN161_n4512 QN=n1482 Q=regfile[5][2] D=n1874
+ CKN=clk_i__L3_N22
Xregfile_reg[5][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n1418
+ SE=FE_OFN80_test_se_i RN=FE_OFN161_n4512 QN=n1483 Q=regfile[5][1] D=n1872
+ CKN=clk_i__L3_N22
Xregfile_reg[5][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n1219
+ SE=FE_OFN115_test_se_i RN=FE_OFN161_n4512 QN=n1484 Q=regfile[5][0] D=n1870
+ CKN=clk_i__L3_N20
Xregfile_reg[28][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n973
+ SE=FE_OFN72_test_se_i RN=n4468 QN=n717 Q=regfile[28][31] D=n3404
+ CKN=clk_i__L3_N27
Xregfile_reg[28][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n686
+ SE=FE_OFN18_test_se_i RN=n4468 QN=n718 Q=regfile[28][30] D=n3402
+ CKN=clk_i__L3_N27
Xregfile_reg[28][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n978
+ SE=FE_OFN102_test_se_i RN=n4468 QN=n719 Q=regfile[28][29] D=n3400
+ CKN=clk_i__L3_N13
Xregfile_reg[28][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n688
+ SE=FE_OFN73_test_se_i RN=n4468 QN=n720 Q=regfile[28][28] D=n3398
+ CKN=clk_i__L3_N13
Xregfile_reg[28][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n720
+ SE=FE_OFN18_test_se_i RN=n4468 QN=n721 Q=regfile[28][27] D=n3396
+ CKN=clk_i__L3_N13
Xregfile_reg[28][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n946
+ SE=FE_OFN18_test_se_i RN=n4468 QN=n722 Q=regfile[28][26] D=n3394
+ CKN=clk_i__L3_N13
Xregfile_reg[28][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n670
+ SE=FE_OFN99_test_se_i RN=n4468 QN=n723 Q=regfile[28][25] D=n3392
+ CKN=clk_i__L3_N15
Xregfile_reg[28][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n685
+ SE=FE_OFN72_test_se_i RN=n4468 QN=n724 Q=regfile[28][24] D=n3390
+ CKN=clk_i__L3_N27
Xregfile_reg[28][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n949
+ SE=FE_OFN100_test_se_i RN=n4468 QN=n725 Q=regfile[28][23] D=n3388
+ CKN=clk_i__L3_N2
Xregfile_reg[28][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n661
+ SE=FE_OFN100_test_se_i RN=n4468 QN=n726 Q=regfile[28][22] D=n3386
+ CKN=clk_i__L3_N2
Xregfile_reg[28][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n696
+ SE=FE_OFN68_test_se_i RN=n4468 QN=n727 Q=regfile[28][21] D=n3384
+ CKN=clk_i__L3_N1
Xregfile_reg[28][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n727
+ SE=FE_OFN68_test_se_i RN=n4468 QN=n728 Q=regfile[28][20] D=n3382
+ CKN=clk_i__L3_N1
Xregfile_reg[28][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n730
+ SE=FE_OFN68_test_se_i RN=n4468 QN=n729 Q=regfile[28][19] D=n3380
+ CKN=clk_i__L3_N1
Xregfile_reg[28][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n698
+ SE=FE_OFN68_test_se_i RN=n4468 QN=n730 Q=regfile[28][18] D=n3378
+ CKN=clk_i__L3_N1
Xregfile_reg[28][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n700
+ SE=FE_OFN68_test_se_i RN=n4469 QN=n731 Q=regfile[28][17] D=n3376
+ CKN=clk_i__L3_N2
Xregfile_reg[28][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n667
+ SE=FE_OFN68_test_se_i RN=n4469 QN=n732 Q=regfile[28][16] D=n3374
+ CKN=clk_i__L3_N2
Xregfile_reg[28][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n925
+ SE=FE_OFN99_test_se_i RN=n4469 QN=n733 Q=regfile[28][15] D=n3372
+ CKN=clk_i__L3_N15
Xregfile_reg[28][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n723
+ SE=FE_OFN99_test_se_i RN=n4469 QN=n734 Q=regfile[28][14] D=n3370
+ CKN=clk_i__L3_N15
Xregfile_reg[28][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n671
+ SE=FE_OFN102_test_se_i RN=n4469 QN=n735 Q=regfile[28][13] D=n3368
+ CKN=clk_i__L3_N13
Xregfile_reg[28][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n928
+ SE=FE_OFN102_test_se_i RN=n4469 QN=n736 Q=regfile[28][12] D=n3366
+ CKN=clk_i__L3_N13
Xregfile_reg[28][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n736
+ SE=FE_OFN83_test_se_i RN=n4469 QN=n737 Q=regfile[28][11] D=n3364
+ CKN=clk_i__L3_N26
Xregfile_reg[28][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n716
+ SE=FE_OFN83_test_se_i RN=n4469 QN=n738 Q=regfile[28][10] D=n3362
+ CKN=clk_i__L3_N26
Xregfile_reg[28][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n931
+ SE=FE_OFN88_test_se_i RN=n4469 QN=n739 Q=regfile[28][9] D=n3360
+ CKN=clk_i__L3_N26
Xregfile_reg[28][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n739
+ SE=FE_OFN106_test_se_i RN=n4469 QN=n740 Q=regfile[28][8] D=n3358
+ CKN=clk_i__L3_N26
Xregfile_reg[28][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n677
+ SE=FE_OFN87_test_se_i RN=n4469 QN=n741 Q=regfile[28][7] D=n3356
+ CKN=clk_i__L3_N7
Xregfile_reg[28][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n741
+ SE=FE_OFN89_test_se_i RN=n4469 QN=n742 Q=regfile[28][6] D=n3354
+ CKN=clk_i__L3_N7
Xregfile_reg[28][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n744
+ SE=FE_OFN89_test_se_i RN=n4469 QN=n743 Q=regfile[28][5] D=n3352
+ CKN=clk_i__L3_N7
Xregfile_reg[28][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n712
+ SE=FE_OFN89_test_se_i RN=n4469 QN=n744 Q=regfile[28][4] D=n3350
+ CKN=clk_i__L3_N7
Xregfile_reg[28][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n681
+ SE=FE_OFN20_test_se_i RN=n4469 QN=SPCASCAN_N28 Q=regfile[28][3] D=n3348
+ CKN=clk_i__L3_N7
Xregfile_reg[28][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n713
+ SE=FE_OFN20_test_se_i RN=n4469 QN=n746 Q=regfile[28][2] D=n3346
+ CKN=clk_i__L3_N26
Xregfile_reg[28][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n589
+ SE=FE_OFN106_test_se_i RN=n4469 QN=n747 Q=regfile[28][1] D=n3344
+ CKN=clk_i__L3_N26
Xregfile_reg[28][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n737
+ SE=FE_OFN83_test_se_i RN=n4469 QN=n748 Q=regfile[28][0] D=n3342
+ CKN=clk_i__L3_N26
Xregfile_reg[24][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n813
+ SE=FE_OFN82_test_se_i RN=n4475 QN=n845 Q=regfile[24][31] D=n3148
+ CKN=clk_i__L3_N6
Xregfile_reg[24][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n749
+ SE=FE_OFN82_test_se_i RN=n4475 QN=n846 Q=regfile[24][30] D=n3146
+ CKN=clk_i__L3_N12
Xregfile_reg[24][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n1042
+ SE=FE_OFN71_test_se_i RN=n4475 QN=n847 Q=regfile[24][29] D=n3144
+ CKN=clk_i__L3_N12
Xregfile_reg[24][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1104
+ SE=FE_OFN92_test_se_i RN=n4475 QN=n848 Q=regfile[24][28] D=n3142
+ CKN=clk_i__L3_N12
Xregfile_reg[24][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n750
+ SE=FE_OFN92_test_se_i RN=n4475 QN=n849 Q=regfile[24][27] D=n3140
+ CKN=clk_i__L3_N12
Xregfile_reg[24][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1103
+ SE=FE_OFN92_test_se_i RN=n4475 QN=n850 Q=regfile[24][26] D=n3138
+ CKN=clk_i__L3_N12
Xregfile_reg[24][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n1043
+ SE=FE_OFN77_test_se_i RN=n4475 QN=n851 Q=regfile[24][25] D=n3136
+ CKN=clk_i__L3_N15
Xregfile_reg[24][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1172
+ SE=FE_OFN85_test_se_i RN=n4475 QN=n852 Q=regfile[24][24] D=n3134
+ CKN=clk_i__L3_N23
Xregfile_reg[24][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n1013
+ SE=FE_OFN61_test_se_i RN=n4475 QN=n853 Q=regfile[24][23] D=n3132 CKN=clk
Xregfile_reg[24][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1109
+ SE=FE_OFN60_test_se_i RN=n4475 QN=n854 Q=regfile[24][22] D=n3130 CKN=clk
Xregfile_reg[24][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n856
+ SE=FE_OFN61_test_se_i RN=n4475 QN=n855 Q=regfile[24][21] D=n3128 CKN=clk
Xregfile_reg[24][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n860
+ SE=FE_OFN61_test_se_i RN=n4475 QN=n856 Q=regfile[24][20] D=n3126 CKN=clk
Xregfile_reg[24][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n858
+ SE=FE_OFN63_test_se_i RN=FE_OFN154_n4476 QN=n857 Q=regfile[24][19] D=n3124
+ CKN=clk_i__L3_N4
Xregfile_reg[24][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n828
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n858 Q=regfile[24][18] D=n3122
+ CKN=clk_i__L3_N4
Xregfile_reg[24][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n763
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n859 Q=regfile[24][17] D=n3120
+ CKN=clk
Xregfile_reg[24][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n824
+ SE=FE_OFN61_test_se_i RN=FE_OFN154_n4476 QN=n860 Q=regfile[24][16] D=n3118
+ CKN=clk
Xregfile_reg[24][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n863
+ SE=FE_OFN70_test_se_i RN=FE_OFN154_n4476 QN=n861 Q=regfile[24][15] D=n3116
+ CKN=clk_i__L3_N14
Xregfile_reg[24][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n861
+ SE=FE_OFN70_test_se_i RN=FE_OFN154_n4476 QN=n862 Q=regfile[24][14] D=n3114
+ CKN=clk_i__L3_N5
Xregfile_reg[24][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n787
+ SE=FE_OFN70_test_se_i RN=FE_OFN154_n4476 QN=n863 Q=regfile[24][13] D=n3112
+ CKN=clk_i__L3_N14
Xregfile_reg[24][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n768
+ SE=FE_OFN71_test_se_i RN=FE_OFN154_n4476 QN=n864 Q=regfile[24][12] D=n3110
+ CKN=clk_i__L3_N14
Xregfile_reg[24][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1163
+ SE=FE_OFN84_test_se_i RN=n4476 QN=n865 Q=regfile[24][11] D=n3108
+ CKN=clk_i__L3_N22
Xregfile_reg[24][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n812
+ SE=FE_OFN85_test_se_i RN=n4476 QN=n866 Q=regfile[24][10] D=n3106
+ CKN=clk_i__L3_N6
Xregfile_reg[24][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n843
+ SE=FE_OFN84_test_se_i RN=n4476 QN=n867 Q=regfile[24][9] D=n3104
+ CKN=clk_i__L3_N6
Xregfile_reg[24][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n810
+ SE=FE_OFN91_test_se_i RN=n4476 QN=n868 Q=regfile[24][8] D=n3102
+ CKN=clk_i__L3_N8
Xregfile_reg[24][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n805
+ SE=FE_OFN90_test_se_i RN=n4476 QN=n869 Q=regfile[24][7] D=n3100
+ CKN=clk_i__L3_N8
Xregfile_reg[24][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n775
+ SE=FE_OFN112_test_se_i RN=n4476 QN=n870 Q=regfile[24][6] D=n3098
+ CKN=clk_i__L3_N8
Xregfile_reg[24][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n1031
+ SE=FE_OFN112_test_se_i RN=n4476 QN=n871 Q=regfile[24][5] D=n3096
+ CKN=clk_i__L3_N8
Xregfile_reg[24][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n870
+ SE=FE_OFN0_test_se_i RN=n4476 QN=n872 Q=regfile[24][4] D=n3094 CKN=clk_i__L3_N8
Xregfile_reg[24][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n842
+ SE=FE_OFN91_test_se_i RN=n4476 QN=n873 Q=regfile[24][3] D=n3092
+ CKN=clk_i__L3_N8
Xregfile_reg[24][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n873
+ SE=FE_OFN113_test_se_i RN=n4476 QN=n874 Q=regfile[24][2] D=n3090
+ CKN=clk_i__L3_N8
Xregfile_reg[24][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n1091
+ SE=FE_OFN85_test_se_i RN=FE_OFN153_n4477 QN=n875 Q=regfile[24][1] D=n3088
+ CKN=clk_i__L3_N6
Xregfile_reg[24][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n875
+ SE=FE_OFN85_test_se_i RN=FE_OFN153_n4477 QN=n876 Q=regfile[24][0] D=n3086
+ CKN=clk_i__L3_N6
Xregfile_reg[20][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n916
+ SE=FE_OFN72_test_se_i RN=n4482 QN=n973 Q=regfile[20][31] D=n2892
+ CKN=clk_i__L3_N27
Xregfile_reg[20][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n878
+ SE=FE_OFN72_test_se_i RN=n4482 QN=n974 Q=regfile[20][30] D=n2890
+ CKN=clk_i__L3_N27
Xregfile_reg[20][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n719
+ SE=FE_OFN102_test_se_i RN=n4482 QN=n975 Q=regfile[20][29] D=n2888
+ CKN=clk_i__L3_N13
Xregfile_reg[20][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n977
+ SE=FE_OFN18_test_se_i RN=n4482 QN=n976 Q=regfile[20][28] D=n2886
+ CKN=clk_i__L3_N13
Xregfile_reg[20][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n943
+ SE=FE_OFN18_test_se_i RN=n4482 QN=n977 Q=regfile[20][27] D=n2884
+ CKN=clk_i__L3_N12
Xregfile_reg[20][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n944
+ SE=FE_OFN18_test_se_i RN=n4482 QN=n978 Q=regfile[20][26] D=n2882
+ CKN=clk_i__L3_N13
Xregfile_reg[20][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n1010
+ SE=FE_OFN99_test_se_i RN=n4482 QN=n979 Q=regfile[20][25] D=n2880
+ CKN=clk_i__L3_N15
Xregfile_reg[20][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n948
+ SE=FE_OFN82_test_se_i RN=n4482 QN=n980 Q=regfile[20][24] D=n2878
+ CKN=clk_i__L3_N6
Xregfile_reg[20][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n885
+ SE=FE_OFN100_test_se_i RN=n4482 QN=n981 Q=regfile[20][23] D=n2876 CKN=clk
Xregfile_reg[20][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n926
+ SE=FE_OFN100_test_se_i RN=n4482 QN=n982 Q=regfile[20][22] D=n2874 CKN=clk
Xregfile_reg[20][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n951
+ SE=FE_OFN67_test_se_i RN=n4483 QN=n983 Q=regfile[20][21] D=n2872
+ CKN=clk_i__L3_N1
Xregfile_reg[20][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n952
+ SE=FE_OFN60_test_se_i RN=n4483 QN=n984 Q=regfile[20][20] D=n2870
+ CKN=clk_i__L3_N1
Xregfile_reg[20][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n955
+ SE=FE_OFN67_test_se_i RN=n4483 QN=n985 Q=regfile[20][19] D=n2868
+ CKN=clk_i__L3_N1
Xregfile_reg[20][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n666
+ SE=FE_OFN68_test_se_i RN=n4483 QN=n986 Q=regfile[20][18] D=n2866
+ CKN=clk_i__L3_N1
Xregfile_reg[20][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n953
+ SE=FE_OFN67_test_se_i RN=n4483 QN=n987 Q=regfile[20][17] D=n2864
+ CKN=clk_i__L3_N1
Xregfile_reg[20][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n985
+ SE=FE_OFN67_test_se_i RN=n4483 QN=n988 Q=regfile[20][16] D=n2862
+ CKN=clk_i__L3_N1
Xregfile_reg[20][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n990
+ SE=FE_OFN100_test_se_i RN=n4483 QN=n989 Q=regfile[20][15] D=n2860
+ CKN=clk_i__L3_N15
Xregfile_reg[20][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n883
+ SE=FE_OFN100_test_se_i RN=n4483 QN=n990 Q=regfile[20][14] D=n2858
+ CKN=clk_i__L3_N15
Xregfile_reg[20][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n893
+ SE=FE_OFN99_test_se_i RN=n4483 QN=n991 Q=regfile[20][13] D=n2856
+ CKN=clk_i__L3_N15
Xregfile_reg[20][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n896
+ SE=FE_OFN102_test_se_i RN=n4483 QN=n992 Q=regfile[20][12] D=n2854
+ CKN=clk_i__L3_N13
Xregfile_reg[20][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n971
+ SE=FE_OFN83_test_se_i RN=n4483 QN=n993 Q=regfile[20][11] D=n2852
+ CKN=clk_i__L3_N26
Xregfile_reg[20][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n877
+ SE=FE_OFN86_test_se_i RN=n4483 QN=n994 Q=regfile[20][10] D=n2850
+ CKN=clk_i__L3_N27
Xregfile_reg[20][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n899
+ SE=FE_OFN88_test_se_i RN=n4483 QN=n995 Q=regfile[20][9] D=n2848
+ CKN=clk_i__L3_N6
Xregfile_reg[20][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n682
+ SE=FE_OFN88_test_se_i RN=n4483 QN=n996 Q=regfile[20][8] D=n2846
+ CKN=clk_i__L3_N26
Xregfile_reg[20][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n933
+ SE=FE_OFN87_test_se_i RN=n4483 QN=n997 Q=regfile[20][7] D=n2844
+ CKN=clk_i__L3_N7
Xregfile_reg[20][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n709
+ SE=FE_OFN89_test_se_i RN=n4483 QN=n998 Q=regfile[20][6] D=n2842
+ CKN=clk_i__L3_N7
Xregfile_reg[20][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n1000
+ SE=FE_OFN9_test_se_i RN=n4483 QN=n999 Q=regfile[20][5] D=n2840 CKN=clk_i__L3_N7
Xregfile_reg[20][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_98_NET SI=n998
+ SE=FE_OFN9_test_se_i RN=n4483 QN=n1000 Q=regfile[20][4] D=n2838
+ CKN=clk_i__L3_N7
Xregfile_reg[20][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n906
+ SE=FE_OFN88_test_se_i RN=n4484 QN=n1001 Q=regfile[20][3] D=n2836
+ CKN=clk_i__L3_N26
Xregfile_reg[20][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET
+ SI=FE_PT1_ICACHE_addr_i_6_ SE=FE_OFN88_test_se_i RN=n4484 QN=n1002
+ Q=regfile[20][2] D=n2834 CKN=clk_i__L3_N6
Xregfile_reg[20][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n897
+ SE=FE_OFN86_test_se_i RN=n4484 QN=n1003 Q=regfile[20][1] D=n2832
+ CKN=clk_i__L3_N26
Xregfile_reg[20][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n980
+ SE=FE_OFN86_test_se_i RN=n4484 QN=n1004 Q=regfile[20][0] D=n2830
+ CKN=clk_i__L3_N6
Xregfile_reg[16][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n1037
+ SE=FE_OFN82_test_se_i RN=n4489 QN=n1101 Q=regfile[16][31] D=n2636
+ CKN=clk_i__L3_N12
Xregfile_reg[16][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n846
+ SE=FE_OFN92_test_se_i RN=n4489 QN=n1102 Q=regfile[16][30] D=n2634
+ CKN=clk_i__L3_N12
Xregfile_reg[16][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n1039
+ SE=FE_OFN75_test_se_i RN=FE_OFN149_n4489 QN=n1103 Q=regfile[16][29] D=n2632
+ CKN=clk_i__L3_N12
Xregfile_reg[16][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1040
+ SE=FE_OFN75_test_se_i RN=FE_OFN149_n4489 QN=n1104 Q=regfile[16][28] D=n2630
+ CKN=clk_i__L3_N12
Xregfile_reg[16][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n849
+ SE=FE_OFN92_test_se_i RN=FE_OFN149_n4489 QN=n1105 Q=regfile[16][27] D=n2628
+ CKN=clk_i__L3_N12
Xregfile_reg[16][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n1074
+ SE=FE_OFN75_test_se_i RN=FE_OFN149_n4489 QN=n1106 Q=regfile[16][26] D=n2626
+ CKN=clk_i__L3_N12
Xregfile_reg[16][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1086
+ SE=FE_OFN77_test_se_i RN=FE_OFN149_n4489 QN=n1107 Q=regfile[16][25] D=n2624
+ CKN=clk_i__L3_N15
Xregfile_reg[16][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n852
+ SE=FE_OFN81_test_se_i RN=n4489 QN=n1108 Q=regfile[16][24] D=n2622
+ CKN=clk_i__L3_N6
Xregfile_reg[16][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n1046
+ SE=FE_OFN60_test_se_i RN=n4490 QN=n1109 Q=regfile[16][23] D=n2620 CKN=clk
Xregfile_reg[16][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n1078
+ SE=FE_OFN60_test_se_i RN=n4490 QN=n1110 Q=regfile[16][22] D=n2618 CKN=clk
Xregfile_reg[16][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n793
+ SE=FE_OFN62_test_se_i RN=n4490 QN=n1111 Q=regfile[16][21] D=n2616
+ CKN=clk_i__L3_N4
Xregfile_reg[16][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1016
+ SE=FE_OFN62_test_se_i RN=n4490 QN=n1112 Q=regfile[16][20] D=n2614 CKN=clk
Xregfile_reg[16][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n1116
+ SE=FE_OFN67_test_se_i RN=n4490 QN=n1113 Q=regfile[16][19] D=n2612
+ CKN=clk_i__L3_N1
Xregfile_reg[16][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1050
+ SE=FE_OFN62_test_se_i RN=n4490 QN=n1114 Q=regfile[16][18] D=n2610
+ CKN=clk_i__L3_N1
Xregfile_reg[16][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n954
+ SE=FE_OFN60_test_se_i RN=n4490 QN=n1115 Q=regfile[16][17] D=n2608
+ CKN=clk_i__L3_N1
Xregfile_reg[16][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n1051
+ SE=FE_OFN66_test_se_i RN=n4490 QN=n1116 Q=regfile[16][16] D=n2606
+ CKN=clk_i__L3_N1
Xregfile_reg[16][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n1054
+ SE=FE_OFN60_test_se_i RN=n4490 QN=n1117 Q=regfile[16][15] D=n2604 CKN=clk
Xregfile_reg[16][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n1117
+ SE=FE_OFN77_test_se_i RN=n4490 QN=n1118 Q=regfile[16][14] D=n2602
+ CKN=clk_i__L3_N15
Xregfile_reg[16][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n1055
+ SE=FE_OFN77_test_se_i RN=n4490 QN=n1119 Q=regfile[16][13] D=n2600
+ CKN=clk_i__L3_N15
Xregfile_reg[16][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1088
+ SE=FE_OFN77_test_se_i RN=n4490 QN=n1120 Q=regfile[16][12] D=n2598
+ CKN=clk_i__L3_N15
Xregfile_reg[16][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1068
+ SE=FE_OFN85_test_se_i RN=n4490 QN=n1121 Q=regfile[16][11] D=n2596
+ CKN=clk_i__L3_N6
Xregfile_reg[16][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1058
+ SE=FE_OFN86_test_se_i RN=n4490 QN=n1122 Q=regfile[16][10] D=n2594
+ CKN=clk_i__L3_N6
Xregfile_reg[16][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n1059
+ SE=FE_OFN113_test_se_i RN=n4490 QN=n1123 Q=regfile[16][9] D=n2592
+ CKN=clk_i__L3_N6
Xregfile_reg[16][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n1035
+ SE=FE_OFN113_test_se_i RN=n4490 QN=n1124 Q=regfile[16][8] D=n2590
+ CKN=clk_i__L3_N6
Xregfile_reg[16][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1061
+ SE=FE_OFN0_test_se_i RN=n4490 QN=n1125 Q=regfile[16][7] D=n2588
+ CKN=clk_i__L3_N8
Xregfile_reg[16][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n1029
+ SE=FE_OFN112_test_se_i RN=n4490 QN=n1126 Q=regfile[16][6] D=n2586
+ CKN=clk_i__L3_N7
Xregfile_reg[16][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n839
+ SE=FE_OFN0_test_se_i RN=n4491 QN=n1127 Q=regfile[16][5] D=n2584
+ CKN=clk_i__L3_N8
Xregfile_reg[16][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n1127
+ SE=FE_OFN0_test_se_i RN=n4491 QN=n1128 Q=regfile[16][4] D=n2582
+ CKN=clk_i__L3_N8
Xregfile_reg[16][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n1093
+ SE=FE_OFN0_test_se_i RN=n4491 QN=n1129 Q=regfile[16][3] D=n2580
+ CKN=clk_i__L3_N8
Xregfile_reg[16][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n1129
+ SE=FE_OFN113_test_se_i RN=n4491 QN=n1130 Q=regfile[16][2] D=n2578
+ CKN=clk_i__L3_N8
Xregfile_reg[16][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n1099
+ SE=FE_OFN85_test_se_i RN=n4491 QN=n1131 Q=regfile[16][1] D=n2576
+ CKN=clk_i__L3_N6
Xregfile_reg[16][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1100
+ SE=FE_OFN85_test_se_i RN=n4491 QN=n1132 Q=regfile[16][0] D=n2574
+ CKN=clk_i__L3_N6
Xregfile_reg[12][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n1197
+ SE=FE_OFN81_test_se_i RN=n4496 QN=n1229 Q=regfile[12][31] D=n2380
+ CKN=clk_i__L3_N23
Xregfile_reg[12][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n1133
+ SE=FE_OFN57_test_se_i RN=n4496 QN=n1230 Q=regfile[12][30] D=n2378
+ CKN=clk_i__L3_N23
Xregfile_reg[12][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1135
+ SE=FE_OFN71_test_se_i RN=n4496 QN=n1231 Q=regfile[12][29] D=n2376
+ CKN=clk_i__L3_N14
Xregfile_reg[12][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n1328
+ SE=FE_OFN92_test_se_i RN=n4496 QN=n1232 Q=regfile[12][28] D=n2374
+ CKN=clk_i__L3_N14
Xregfile_reg[12][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1137
+ SE=FE_OFN57_test_se_i RN=n4496 QN=n1233 Q=regfile[12][27] D=n2372
+ CKN=clk_i__L3_N23
Xregfile_reg[12][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1170
+ SE=FE_OFN92_test_se_i RN=n4496 QN=n1234 Q=regfile[12][26] D=n2370
+ CKN=clk_i__L3_N14
Xregfile_reg[12][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n1151
+ SE=FE_OFN69_test_se_i RN=n4497 QN=n1235 Q=regfile[12][25] D=n2368
+ CKN=clk_i__L3_N14
Xregfile_reg[12][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n1140
+ SE=FE_OFN81_test_se_i RN=n4497 QN=n1236 Q=regfile[12][24] D=n2366
+ CKN=clk_i__L3_N23
Xregfile_reg[12][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n1301
+ SE=FE_OFN63_test_se_i RN=n4497 QN=n1237 Q=regfile[12][23] D=n2364
+ CKN=clk_i__L3_N5
Xregfile_reg[12][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n1237
+ SE=FE_OFN69_test_se_i RN=n4497 QN=n1238 Q=regfile[12][22] D=n2362
+ CKN=clk_i__L3_N5
Xregfile_reg[12][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1336
+ SE=FE_OFN66_test_se_i RN=n4497 QN=n1239 Q=regfile[12][21] D=n2360
+ CKN=clk_i__L3_N4
Xregfile_reg[12][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n1146
+ SE=FE_OFN63_test_se_i RN=n4497 QN=n1240 Q=regfile[12][20] D=n2358
+ CKN=clk_i__L3_N4
Xregfile_reg[12][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1495
+ SE=FE_OFN65_test_se_i RN=n4497 QN=n1241 Q=regfile[12][19] D=n2356
+ CKN=clk_i__L3_N4
Xregfile_reg[12][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1179
+ SE=FE_OFN64_test_se_i RN=n4497 QN=n1242 Q=regfile[12][18] D=n2354
+ CKN=clk_i__L3_N4
Xregfile_reg[12][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1242
+ SE=FE_OFN65_test_se_i RN=n4497 QN=n1243 Q=regfile[12][17] D=n2352
+ CKN=clk_i__L3_N4
Xregfile_reg[12][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1468
+ SE=FE_OFN17_test_se_i RN=n4497 QN=n1244 Q=regfile[12][16] D=n2350
+ CKN=clk_i__L3_N5
Xregfile_reg[12][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1213
+ SE=FE_OFN69_test_se_i RN=n4497 QN=n1245 Q=regfile[12][15] D=n2348
+ CKN=clk_i__L3_N18
Xregfile_reg[12][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1278
+ SE=FE_OFN76_test_se_i RN=n4497 QN=n1246 Q=regfile[12][14] D=n2346
+ CKN=clk_i__L3_N18
Xregfile_reg[12][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1311
+ SE=FE_OFN7_test_se_i RN=n4497 QN=n1247 Q=regfile[12][13] D=n2344
+ CKN=clk_i__L3_N18
Xregfile_reg[12][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n1343
+ SE=FE_OFN74_test_se_i RN=n4497 QN=n1248 Q=regfile[12][12] D=n2342
+ CKN=clk_i__L3_N18
Xregfile_reg[12][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1217
+ SE=FE_OFN115_test_se_i RN=n4497 QN=n1249 Q=regfile[12][11] D=n2340
+ CKN=clk_i__L3_N23
Xregfile_reg[12][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1452
+ SE=FE_OFN115_test_se_i RN=n4497 QN=n1250 Q=regfile[12][10] D=n2338
+ CKN=clk_i__L3_N23
Xregfile_reg[12][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1346
+ SE=FE_OFN115_test_se_i RN=n4497 QN=n1251 Q=regfile[12][9] D=n2336
+ CKN=clk_i__L3_N20
Xregfile_reg[12][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n1187
+ SE=FE_OFN80_test_se_i RN=n4497 QN=n1252 Q=regfile[12][8] D=n2334
+ CKN=clk_i__L3_N20
Xregfile_reg[12][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n1350
+ SE=FE_OFN78_test_se_i RN=n4498 QN=n1253 Q=regfile[12][7] D=n2332
+ CKN=clk_i__L3_N21
Xregfile_reg[12][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n1222
+ SE=FE_OFN79_test_se_i RN=n4498 QN=n1254 Q=regfile[12][6] D=n2330
+ CKN=clk_i__L3_N21
Xregfile_reg[12][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n1159
+ SE=FE_OFN79_test_se_i RN=n4498 QN=n1255 Q=regfile[12][5] D=n2328
+ CKN=clk_i__L3_N21
Xregfile_reg[12][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n1255
+ SE=FE_OFN79_test_se_i RN=n4498 QN=n1256 Q=regfile[12][4] D=n2326
+ CKN=clk_i__L3_N21
Xregfile_reg[12][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n808
+ SE=FE_OFN12_test_se_i RN=n4498 QN=n1257 Q=regfile[12][3] D=n2324
+ CKN=clk_i__L3_N8
Xregfile_reg[12][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n1162
+ SE=FE_OFN91_test_se_i RN=n4498 QN=n1258 Q=regfile[12][2] D=n2322
+ CKN=clk_i__L3_N22
Xregfile_reg[12][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1356
+ SE=FE_OFN84_test_se_i RN=n4498 QN=n1259 Q=regfile[12][1] D=n2320
+ CKN=clk_i__L3_N22
Xregfile_reg[12][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n770
+ SE=FE_OFN85_test_se_i RN=n4498 QN=n1260 Q=regfile[12][0] D=n2318
+ CKN=clk_i__L3_N23
Xregfile_reg[8][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1326
+ SE=FE_OFN57_test_se_i RN=n4503 QN=n1357 Q=regfile[8][31] D=n2124
+ CKN=clk_i__L3_N23
Xregfile_reg[8][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1265
+ SE=FE_OFN57_test_se_i RN=n4503 QN=n1358 Q=regfile[8][30] D=n2122
+ CKN=clk_i__L3_N23
Xregfile_reg[8][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n819
+ SE=FE_OFN74_test_se_i RN=n4503 QN=n1359 Q=regfile[8][29] D=n2120
+ CKN=clk_i__L3_N18
Xregfile_reg[8][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n1362
+ SE=FE_OFN58_test_se_i RN=n4503 QN=n1360 Q=regfile[8][28] D=n2118
+ CKN=clk_i__L3_N14
Xregfile_reg[8][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n1393
+ SE=FE_OFN58_test_se_i RN=n4504 QN=n1361 Q=regfile[8][27] D=n2116
+ CKN=clk_i__L3_N17
Xregfile_reg[8][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1455
+ SE=FE_OFN74_test_se_i RN=n4504 QN=n1362 Q=regfile[8][26] D=n2114
+ CKN=clk_i__L3_N18
Xregfile_reg[8][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n1331
+ SE=FE_OFN69_test_se_i RN=n4504 QN=n1363 Q=regfile[8][25] D=n2112
+ CKN=clk_i__L3_N14
Xregfile_reg[8][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1153
+ SE=FE_OFN81_test_se_i RN=n4504 QN=n1364 Q=regfile[8][24] D=n2110
+ CKN=clk_i__L3_N23
Xregfile_reg[8][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n1429
+ SE=FE_OFN63_test_se_i RN=n4504 QN=n1365 Q=regfile[8][23] D=n2108
+ CKN=clk_i__L3_N5
Xregfile_reg[8][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1334
+ SE=FE_OFN69_test_se_i RN=n4504 QN=n1366 Q=regfile[8][22] D=n2106
+ CKN=clk_i__L3_N5
Xregfile_reg[8][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n1273
+ SE=FE_OFN17_test_se_i RN=n4504 QN=n1367 Q=regfile[8][21] D=n2104
+ CKN=clk_i__L3_N4
Xregfile_reg[8][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1272
+ SE=FE_OFN66_test_se_i RN=n4504 QN=n1368 Q=regfile[8][20] D=n2102
+ CKN=clk_i__L3_N4
Xregfile_reg[8][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1340
+ SE=FE_OFN65_test_se_i RN=n4504 QN=n1369 Q=regfile[8][19] D=n2100
+ CKN=clk_i__L3_N4
Xregfile_reg[8][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n1339
+ SE=FE_OFN65_test_se_i RN=n4504 QN=n1370 Q=regfile[8][18] D=n2098
+ CKN=clk_i__L3_N4
Xregfile_reg[8][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n1372
+ SE=FE_OFN65_test_se_i RN=n4504 QN=n1371 Q=regfile[8][17] D=n2096
+ CKN=clk_i__L3_N4
Xregfile_reg[8][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1275
+ SE=FE_OFN65_test_se_i RN=n4504 QN=n1372 Q=regfile[8][16] D=n2094
+ CKN=clk_i__L3_N3
Xregfile_reg[8][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1469
+ SE=FE_OFN1_test_se_i RN=n4504 QN=n1373 Q=regfile[8][15] D=n2092
+ CKN=clk_i__L3_N18
Xregfile_reg[8][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n1493
+ SE=FE_OFN17_test_se_i RN=n4504 QN=n1374 Q=regfile[8][14] D=n2090
+ CKN=clk_i__L3_N3
Xregfile_reg[8][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1247
+ SE=FE_OFN22_test_se_i RN=n4504 QN=n1375 Q=regfile[8][13] D=n2088
+ CKN=clk_i__L3_N18
Xregfile_reg[8][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1184
+ SE=FE_OFN74_test_se_i RN=n4504 QN=n1376 Q=regfile[8][12] D=n2086
+ CKN=clk_i__L3_N18
Xregfile_reg[8][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n1345
+ SE=FE_OFN56_test_se_i RN=n4504 QN=n1377 Q=regfile[8][11] D=n2084
+ CKN=clk_i__L3_N17
Xregfile_reg[8][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1185
+ SE=FE_OFN115_test_se_i RN=n4504 QN=n1378 Q=regfile[8][10] D=n2082
+ CKN=clk_i__L3_N20
Xregfile_reg[8][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1251
+ SE=FE_OFN115_test_se_i RN=n4505 QN=n1379 Q=regfile[8][9] D=n2080
+ CKN=clk_i__L3_N20
Xregfile_reg[8][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1348
+ SE=FE_OFN78_test_se_i RN=n4505 QN=n1380 Q=regfile[8][8] D=n2078
+ CKN=clk_i__L3_N21
Xregfile_reg[8][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1286
+ SE=FE_OFN78_test_se_i RN=n4505 QN=n1381 Q=regfile[8][7] D=n2076
+ CKN=clk_i__L3_N21
Xregfile_reg[8][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1415
+ SE=FE_OFN78_test_se_i RN=n4505 QN=n1382 Q=regfile[8][6] D=n2074
+ CKN=clk_i__L3_N21
Xregfile_reg[8][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1351
+ SE=FE_OFN90_test_se_i RN=n4505 QN=n1383 Q=regfile[8][5] D=n2072
+ CKN=clk_i__L3_N22
Xregfile_reg[8][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n1320
+ SE=FE_OFN90_test_se_i RN=n4505 QN=n1384 Q=regfile[8][4] D=n2070
+ CKN=clk_i__L3_N22
Xregfile_reg[8][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n1322
+ SE=FE_OFN90_test_se_i RN=n4505 QN=n1385 Q=regfile[8][3] D=n2068
+ CKN=clk_i__L3_N22
Xregfile_reg[8][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1289
+ SE=FE_OFN90_test_se_i RN=n4505 QN=n1386 Q=regfile[8][2] D=n2066
+ CKN=clk_i__L3_N22
Xregfile_reg[8][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1220
+ SE=FE_OFN80_test_se_i RN=n4505 QN=n1387 Q=regfile[8][1] D=n2064
+ CKN=clk_i__L3_N22
Xregfile_reg[8][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1324
+ SE=FE_OFN80_test_se_i RN=n4505 QN=n1388 Q=regfile[8][0] D=n2062
+ CKN=clk_i__L3_N22
Xregfile_reg[4][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n1453
+ SE=FE_OFN56_test_se_i RN=n4512 QN=n1485 Q=regfile[4][31] D=n1868
+ CKN=clk_i__L3_N17
Xregfile_reg[4][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n1261
+ SE=FE_OFN57_test_se_i RN=n4512 QN=n1486 Q=regfile[4][30] D=n1866
+ CKN=clk_i__L3_N23
Xregfile_reg[4][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1298
+ SE=FE_OFN58_test_se_i RN=n4511 QN=n1487 Q=regfile[4][29] D=n1864
+ CKN=clk_i__L3_N18
Xregfile_reg[4][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n1424
+ SE=FE_OFN58_test_se_i RN=n4511 QN=n1488 Q=regfile[4][28] D=n1862
+ CKN=clk_i__L3_N14
Xregfile_reg[4][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1457
+ SE=FE_OFN56_test_se_i RN=n4511 QN=n1489 Q=regfile[4][27] D=n1860
+ CKN=clk_i__L3_N17
Xregfile_reg[4][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n1280
+ SE=FE_OFN56_test_se_i RN=n4511 QN=n1490 Q=regfile[4][26] D=n1858
+ CKN=clk_i__L3_N18
Xregfile_reg[4][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1363
+ SE=FE_OFN69_test_se_i RN=n4511 QN=n1491 Q=regfile[4][25] D=n1856
+ CKN=clk_i__L3_N18
Xregfile_reg[4][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n1293
+ SE=FE_OFN115_test_se_i RN=n4511 QN=n1492 Q=regfile[4][24] D=n1854
+ CKN=clk_i__L3_N23
Xregfile_reg[4][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1502
+ SE=FE_OFN76_test_se_i RN=n4511 QN=n1493 Q=regfile[4][23] D=n1852
+ CKN=clk_i__L3_N5
Xregfile_reg[4][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1244
+ SE=FE_OFN17_test_se_i RN=n4511 QN=n1494 Q=regfile[4][22] D=n1850
+ CKN=clk_i__L3_N5
Xregfile_reg[4][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1400
+ SE=FE_OFN64_test_se_i RN=n4511 QN=n1495 Q=regfile[4][21] D=n1848
+ CKN=clk_i__L3_N4
Xregfile_reg[4][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n1210
+ SE=FE_OFN64_test_se_i RN=n4511 QN=n1496 Q=regfile[4][20] D=n1846
+ CKN=clk_i__L3_N5
Xregfile_reg[4][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1401
+ SE=FE_OFN55_test_se_i RN=n4511 QN=n1497 Q=regfile[4][19] D=n1844
+ CKN=clk_i__L3_N3
Xregfile_reg[4][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1594
+ SE=FE_OFN55_test_se_i RN=n4511 QN=n1498 Q=regfile[4][18] D=n1842
+ CKN=clk_i__L3_N3
Xregfile_reg[4][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n1243
+ SE=FE_OFN64_test_se_i RN=n4511 QN=n1499 Q=regfile[4][17] D=n1840
+ CKN=clk_i__L3_N4
Xregfile_reg[4][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n1436
+ SE=FE_OFN76_test_se_i RN=n4511 QN=n1500 Q=regfile[4][16] D=n1838
+ CKN=clk_i__L3_N3
Xregfile_reg[4][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n1373
+ SE=FE_OFN1_test_se_i RN=n4511 QN=n1501 Q=regfile[4][15] D=n1836
+ CKN=clk_i__L3_N18
Xregfile_reg[4][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n1590
+ SE=FE_OFN54_test_se_i RN=n4511 QN=n1502 Q=regfile[4][14] D=n1834
+ CKN=clk_i__L3_N18
Xregfile_reg[4][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1407
+ SE=FE_OFN4_test_se_i RN=n4511 QN=n1503 Q=regfile[4][13] D=n1832
+ CKN=clk_i__L3_N18
Xregfile_reg[4][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n1472
+ SE=FE_OFN4_test_se_i RN=n4511 QN=n1504 Q=regfile[4][12] D=n1830
+ CKN=clk_i__L3_N18
Xregfile_reg[4][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1410
+ SE=FE_OFN3_test_se_i RN=n4512 QN=n1505 Q=regfile[4][11] D=n1828
+ CKN=clk_i__L3_N17
Xregfile_reg[4][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1442
+ SE=FE_OFN114_test_se_i RN=n4512 QN=n1506 Q=regfile[4][10] D=n1826
+ CKN=clk_i__L3_N20
Xregfile_reg[4][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1443
+ SE=FE_OFN114_test_se_i RN=FE_OFN161_n4512 QN=n1507 Q=regfile[4][9] D=n1824
+ CKN=clk_i__L3_N20
Xregfile_reg[4][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1412
+ SE=FE_OFN111_test_se_i RN=FE_OFN161_n4512 QN=n1508 Q=regfile[4][8] D=n1822
+ CKN=clk_i__L3_N20
Xregfile_reg[4][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1446
+ SE=FE_OFN78_test_se_i RN=FE_OFN161_n4512 QN=n1509 Q=regfile[4][7] D=n1820
+ CKN=clk_i__L3_N21
Xregfile_reg[4][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1511
+ SE=FE_OFN78_test_se_i RN=FE_OFN161_n4512 QN=n1510 Q=regfile[4][6] D=n1818
+ CKN=clk_i__L3_N21
Xregfile_reg[4][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1414
+ SE=FE_OFN78_test_se_i RN=FE_OFN161_n4512 QN=n1511 Q=regfile[4][5] D=n1816
+ CKN=clk_i__L3_N21
Xregfile_reg[4][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1513
+ SE=FE_OFN79_test_se_i RN=FE_OFN161_n4512 QN=n1512 Q=regfile[4][4] D=n1814
+ CKN=clk_i__L3_N21
Xregfile_reg[4][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1288
+ SE=FE_OFN79_test_se_i RN=FE_OFN161_n4512 QN=n1513 Q=regfile[4][3] D=n1812
+ CKN=clk_i__L3_N22
Xregfile_reg[4][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n1481
+ SE=FE_OFN80_test_se_i RN=FE_OFN161_n4512 QN=n1514 Q=regfile[4][2] D=n1810
+ CKN=clk_i__L3_N22
Xregfile_reg[4][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1155
+ SE=FE_OFN80_test_se_i RN=FE_OFN161_n4512 QN=n1515 Q=regfile[4][1] D=n1808
+ CKN=clk_i__L3_N20
Xregfile_reg[4][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1484
+ SE=FE_OFN115_test_se_i RN=FE_OFN161_n4512 QN=n1516 Q=regfile[4][0] D=n1806
+ CKN=clk_i__L3_N20
Xregfile_reg[30][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n9
+ SE=FE_OFN72_test_se_i RN=FE_OFN158_n4465 QN=n653 Q=regfile[30][31] D=n3532
+ CKN=clk_i__L3_N27
Xregfile_reg[30][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_53_NET SI=n657
+ SE=FE_OFN18_test_se_i RN=FE_OFN158_n4465 QN=n654 Q=regfile[30][30] D=n3530
+ CKN=clk_i__L3_N13
Xregfile_reg[30][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n571
+ SE=FE_OFN73_test_se_i RN=FE_OFN158_n4465 QN=n655 Q=regfile[30][29] D=n3528
+ CKN=clk_i__L3_N13
Xregfile_reg[30][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n13
+ SE=FE_OFN73_test_se_i RN=FE_OFN158_n4465 QN=n656 Q=regfile[30][28] D=n3526
+ CKN=clk_i__L3_N13
Xregfile_reg[30][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n572
+ SE=FE_OFN73_test_se_i RN=FE_OFN158_n4465 QN=n657 Q=regfile[30][27] D=n3524
+ CKN=clk_i__L3_N13
Xregfile_reg[30][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_45_NET SI=n574
+ SE=FE_OFN73_test_se_i RN=FE_OFN158_n4465 QN=n658 Q=regfile[30][26] D=n3522
+ CKN=clk_i__L3_N13
Xregfile_reg[30][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n586
+ SE=FE_OFN102_test_se_i RN=FE_OFN158_n4465 QN=n659 Q=regfile[30][25] D=n3520
+ CKN=clk_i__L3_N13
Xregfile_reg[30][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n692
+ SE=FE_OFN72_test_se_i RN=FE_OFN158_n4465 QN=n660 Q=regfile[30][24] D=n3518
+ CKN=clk_i__L3_N27
Xregfile_reg[30][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n725
+ SE=FE_OFN100_test_se_i RN=FE_OFN158_n4465 QN=n661 Q=regfile[30][23] D=n3516
+ CKN=clk_i__L3_N2
Xregfile_reg[30][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n950
+ SE=FE_OFN100_test_se_i RN=FE_OFN158_n4465 QN=n662 Q=regfile[30][22] D=n3514
+ CKN=clk
Xregfile_reg[30][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n981
+ SE=FE_OFN60_test_se_i RN=FE_OFN158_n4465 QN=n663 Q=regfile[30][21] D=n3512
+ CKN=clk
Xregfile_reg[30][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n665
+ SE=FE_OFN68_test_se_i RN=FE_OFN158_n4465 QN=n664 Q=regfile[30][20] D=n3510
+ CKN=clk_i__L3_N1
Xregfile_reg[30][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n729
+ SE=FE_OFN68_test_se_i RN=FE_OFN158_n4465 QN=n665 Q=regfile[30][19] D=n3508
+ CKN=clk_i__L3_N1
Xregfile_reg[30][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n728
+ SE=FE_OFN67_test_se_i RN=FE_OFN158_n4465 QN=n666 Q=regfile[30][18] D=n3506
+ CKN=clk_i__L3_N1
Xregfile_reg[30][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_15_NET SI=n668
+ SE=FE_OFN68_test_se_i RN=FE_OFN158_n4465 QN=n667 Q=regfile[30][17] D=n3504
+ CKN=clk_i__L3_N2
Xregfile_reg[30][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n984
+ SE=FE_OFN68_test_se_i RN=FE_OFN158_n4465 QN=n668 Q=regfile[30][16] D=n3502
+ CKN=clk_i__L3_N2
Xregfile_reg[30][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n733
+ SE=FE_OFN99_test_se_i RN=FE_OFN158_n4465 QN=n669 Q=regfile[30][15] D=n3500
+ CKN=clk_i__L3_N2
Xregfile_reg[30][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n989
+ SE=FE_OFN99_test_se_i RN=FE_OFN158_n4465 QN=n670 Q=regfile[30][14] D=n3498
+ CKN=clk_i__L3_N15
Xregfile_reg[30][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n701
+ SE=FE_OFN102_test_se_i RN=FE_OFN158_n4465 QN=n671 Q=regfile[30][13] D=n3496
+ CKN=clk_i__L3_N15
Xregfile_reg[30][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n735
+ SE=FE_OFN102_test_se_i RN=FE_OFN158_n4465 QN=n672 Q=regfile[30][12] D=n3494
+ CKN=clk_i__L3_N13
Xregfile_reg[30][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n683
+ SE=FE_OFN83_test_se_i RN=n4465 QN=n673 Q=regfile[30][11] D=n3492
+ CKN=clk_i__L3_N26
Xregfile_reg[30][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n748
+ SE=FE_OFN83_test_se_i RN=n4465 QN=n674 Q=regfile[30][10] D=n3490
+ CKN=clk_i__L3_N26
Xregfile_reg[30][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n674
+ SE=FE_OFN106_test_se_i RN=n4465 QN=n675 Q=regfile[30][9] D=n3488
+ CKN=clk_i__L3_N26
Xregfile_reg[30][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n707
+ SE=FE_OFN88_test_se_i RN=n4465 QN=n676 Q=regfile[30][8] D=n3486
+ CKN=clk_i__L3_N26
Xregfile_reg[30][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n676
+ SE=FE_OFN87_test_se_i RN=n4466 QN=n677 Q=regfile[30][7] D=n3484
+ CKN=clk_i__L3_N7
Xregfile_reg[30][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n680
+ SE=FE_OFN89_test_se_i RN=n4466 QN=n678 Q=regfile[30][6] D=n3482
+ CKN=clk_i__L3_N7
Xregfile_reg[30][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n710
+ SE=FE_OFN89_test_se_i RN=n4466 QN=n679 Q=regfile[30][5] D=n3480
+ CKN=clk_i__L3_N7
Xregfile_reg[30][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n679
+ SE=FE_OFN89_test_se_i RN=n4466 QN=n680 Q=regfile[30][4] D=n3478
+ CKN=clk_i__L3_N7
Xregfile_reg[30][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n1001
+ SE=FE_OFN88_test_se_i RN=n4466 QN=n681 Q=regfile[30][3] D=n3476
+ CKN=clk_i__L3_N7
Xregfile_reg[30][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_82_NET SI=n932
+ SE=FE_OFN88_test_se_i RN=n4466 QN=n682 Q=regfile[30][2] D=n3474
+ CKN=clk_i__L3_N26
Xregfile_reg[30][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n993
+ SE=FE_OFN83_test_se_i RN=n4466 QN=n683 Q=regfile[30][1] D=n3472
+ CKN=clk_i__L3_N26
Xregfile_reg[30][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n706
+ SE=FE_OFN83_test_se_i RN=n4466 QN=n684 Q=regfile[30][0] D=n3470
+ CKN=clk_i__L3_N26
Xregfile_reg[26][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n756
+ SE=FE_OFN57_test_se_i RN=n4472 QN=n781 Q=regfile[26][31] D=n3276
+ CKN=clk_i__L3_N12
Xregfile_reg[26][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n753
+ SE=FE_OFN57_test_se_i RN=FE_OFN157_n4472 QN=n782 Q=regfile[26][30] D=n3274
+ CKN=clk_i__L3_N23
Xregfile_reg[26][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_41_NET SI=n815
+ SE=FE_OFN71_test_se_i RN=FE_OFN157_n4472 QN=n783 Q=regfile[26][29] D=n3272
+ CKN=clk_i__L3_N14
Xregfile_reg[26][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n754
+ SE=FE_OFN71_test_se_i RN=FE_OFN157_n4472 QN=n784 Q=regfile[26][28] D=n3270
+ CKN=clk_i__L3_N14
Xregfile_reg[26][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1168
+ SE=FE_OFN92_test_se_i RN=FE_OFN157_n4472 QN=n785 Q=regfile[26][27] D=n3268
+ CKN=clk_i__L3_N23
Xregfile_reg[26][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n818
+ SE=FE_OFN71_test_se_i RN=FE_OFN157_n4472 QN=n786 Q=regfile[26][26] D=n3266
+ CKN=clk_i__L3_N14
Xregfile_reg[26][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n755
+ SE=FE_OFN71_test_se_i RN=FE_OFN157_n4472 QN=n787 Q=regfile[26][25] D=n3264
+ CKN=clk_i__L3_N14
Xregfile_reg[26][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n820
+ SE=FE_OFN81_test_se_i RN=n4472 QN=n788 Q=regfile[26][24] D=n3262
+ CKN=clk_i__L3_N6
Xregfile_reg[26][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n757
+ SE=FE_OFN63_test_se_i RN=FE_OFN157_n4472 QN=n789 Q=regfile[26][23] D=n3260
+ CKN=clk_i__L3_N5
Xregfile_reg[26][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n821
+ SE=FE_OFN70_test_se_i RN=FE_OFN157_n4472 QN=n790 Q=regfile[26][22] D=n3258
+ CKN=clk
Xregfile_reg[26][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n794
+ SE=FE_OFN66_test_se_i RN=FE_OFN157_n4472 QN=n791 Q=regfile[26][21] D=n3256
+ CKN=clk_i__L3_N4
Xregfile_reg[26][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_3_NET SI=n1111
+ SE=FE_OFN62_test_se_i RN=FE_OFN157_n4472 QN=n792 Q=regfile[26][20] D=n3254
+ CKN=clk_i__L3_N4
Xregfile_reg[26][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_2_NET SI=n796
+ SE=FE_OFN66_test_se_i RN=FE_OFN157_n4472 QN=n793 Q=regfile[26][19] D=n3252
+ CKN=clk_i__L3_N4
Xregfile_reg[26][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n761
+ SE=FE_OFN66_test_se_i RN=FE_OFN157_n4472 QN=n794 Q=regfile[26][18] D=n3250
+ CKN=clk_i__L3_N4
Xregfile_reg[26][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n1143
+ SE=FE_OFN63_test_se_i RN=FE_OFN157_n4472 QN=n795 Q=regfile[26][17] D=n3248
+ CKN=clk_i__L3_N5
Xregfile_reg[26][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1304
+ SE=FE_OFN66_test_se_i RN=FE_OFN157_n4472 QN=n796 Q=regfile[26][16] D=n3246
+ CKN=clk_i__L3_N4
Xregfile_reg[26][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n798
+ SE=FE_OFN70_test_se_i RN=FE_OFN157_n4472 QN=n797 Q=regfile[26][15] D=n3244
+ CKN=clk_i__L3_N5
Xregfile_reg[26][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n1174
+ SE=FE_OFN70_test_se_i RN=FE_OFN157_n4472 QN=n798 Q=regfile[26][14] D=n3242
+ CKN=clk_i__L3_N5
Xregfile_reg[26][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1139
+ SE=FE_OFN70_test_se_i RN=FE_OFN157_n4472 QN=n799 Q=regfile[26][13] D=n3240
+ CKN=clk_i__L3_N14
Xregfile_reg[26][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n864
+ SE=FE_OFN71_test_se_i RN=FE_OFN157_n4472 QN=n800 Q=regfile[26][12] D=n3238
+ CKN=clk_i__L3_N14
Xregfile_reg[26][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1164
+ SE=FE_OFN81_test_se_i RN=n4472 QN=n801 Q=regfile[26][11] D=n3236
+ CKN=clk_i__L3_N23
Xregfile_reg[26][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n866
+ SE=FE_OFN85_test_se_i RN=n4472 QN=n802 Q=regfile[26][10] D=n3234
+ CKN=clk_i__L3_N6
Xregfile_reg[26][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1226
+ SE=FE_OFN11_test_se_i RN=n4473 QN=n803 Q=regfile[26][9] D=n3232
+ CKN=clk_i__L3_N22
Xregfile_reg[26][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n778
+ SE=FE_OFN91_test_se_i RN=n4473 QN=n804 Q=regfile[26][8] D=n3230
+ CKN=clk_i__L3_N22
Xregfile_reg[26][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n773
+ SE=FE_OFN90_test_se_i RN=n4473 QN=n805 Q=regfile[26][7] D=n3228
+ CKN=clk_i__L3_N8
Xregfile_reg[26][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1257
+ SE=FE_OFN90_test_se_i RN=n4473 QN=n806 Q=regfile[26][6] D=n3226
+ CKN=clk_i__L3_N8
Xregfile_reg[26][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n840
+ SE=FE_OFN0_test_se_i RN=n4473 QN=n807 Q=regfile[26][5] D=n3224 CKN=clk_i__L3_N8
Xregfile_reg[26][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n776
+ SE=FE_OFN12_test_se_i RN=n4473 QN=n808 Q=regfile[26][4] D=n3222
+ CKN=clk_i__L3_N8
Xregfile_reg[26][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n777
+ SE=FE_OFN91_test_se_i RN=n4473 QN=n809 Q=regfile[26][3] D=n3220
+ CKN=clk_i__L3_N22
Xregfile_reg[26][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n772
+ SE=FE_OFN91_test_se_i RN=n4473 QN=n810 Q=regfile[26][2] D=n3218
+ CKN=clk_i__L3_N22
Xregfile_reg[26][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1123
+ SE=FE_OFN85_test_se_i RN=n4473 QN=n811 Q=regfile[26][1] D=n3216
+ CKN=clk_i__L3_N6
Xregfile_reg[26][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n844
+ SE=FE_OFN84_test_se_i RN=n4473 QN=n812 Q=regfile[26][0] D=n3214
+ CKN=clk_i__L3_N23
Xregfile_reg[22][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n910
+ SE=FE_OFN82_test_se_i RN=FE_OFN151_n4481 QN=n909 Q=regfile[22][31] D=n3020
+ CKN=clk_i__L3_N12
Xregfile_reg[22][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n942
+ SE=FE_OFN72_test_se_i RN=FE_OFN151_n4481 QN=n910 Q=regfile[22][30] D=n3018
+ CKN=clk_i__L3_N12
Xregfile_reg[22][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n975
+ SE=FE_OFN102_test_se_i RN=FE_OFN152_n4480 QN=n911 Q=regfile[22][29] D=n3016
+ CKN=clk_i__L3_N12
Xregfile_reg[22][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n880
+ SE=FE_OFN75_test_se_i RN=FE_OFN152_n4480 QN=n912 Q=regfile[22][28] D=n3014
+ CKN=clk_i__L3_N12
Xregfile_reg[22][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_51_NET SI=n1073
+ SE=FE_OFN75_test_se_i RN=FE_OFN152_n4480 QN=n913 Q=regfile[22][27] D=n3012
+ CKN=clk_i__L3_N12
Xregfile_reg[22][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n911
+ SE=FE_OFN75_test_se_i RN=FE_OFN152_n4480 QN=n914 Q=regfile[22][26] D=n3010
+ CKN=clk_i__L3_N12
Xregfile_reg[22][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_30_NET SI=n1053
+ SE=FE_OFN99_test_se_i RN=FE_OFN152_n4480 QN=n915 Q=regfile[22][25] D=n3008
+ CKN=clk_i__L3_N15
Xregfile_reg[22][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n1005
+ SE=FE_OFN82_test_se_i RN=n4480 QN=n916 Q=regfile[22][24] D=n3006
+ CKN=clk_i__L3_N6
Xregfile_reg[22][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n888
+ SE=FE_OFN60_test_se_i RN=FE_OFN152_n4480 QN=n917 Q=regfile[22][23] D=n3004
+ CKN=clk
Xregfile_reg[22][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_20_NET SI=n886
+ SE=FE_OFN100_test_se_i RN=FE_OFN152_n4480 QN=n918 Q=regfile[22][22] D=n3002
+ CKN=clk
Xregfile_reg[22][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1113
+ SE=FE_OFN66_test_se_i RN=FE_OFN152_n4480 QN=n919 Q=regfile[22][21] D=n3000
+ CKN=clk_i__L3_N1
Xregfile_reg[22][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n921
+ SE=FE_OFN60_test_se_i RN=FE_OFN152_n4480 QN=n920 Q=regfile[22][20] D=n2998
+ CKN=clk_i__L3_N1
Xregfile_reg[22][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n663
+ SE=FE_OFN60_test_se_i RN=FE_OFN152_n4480 QN=n921 Q=regfile[22][19] D=n2996
+ CKN=clk_i__L3_N1
Xregfile_reg[22][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n891
+ SE=FE_OFN67_test_se_i RN=FE_OFN152_n4480 QN=n922 Q=regfile[22][18] D=n2994
+ CKN=clk_i__L3_N1
Xregfile_reg[22][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n924
+ SE=FE_OFN67_test_se_i RN=FE_OFN152_n4480 QN=n923 Q=regfile[22][17] D=n2992
+ CKN=clk_i__L3_N1
Xregfile_reg[22][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n892
+ SE=FE_OFN67_test_se_i RN=FE_OFN152_n4480 QN=n924 Q=regfile[22][16] D=n2990
+ CKN=clk_i__L3_N1
Xregfile_reg[22][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n734
+ SE=FE_OFN99_test_se_i RN=FE_OFN152_n4480 QN=n925 Q=regfile[22][15] D=n2988
+ CKN=clk_i__L3_N15
Xregfile_reg[22][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_26_NET SI=n894
+ SE=FE_OFN100_test_se_i RN=FE_OFN152_n4480 QN=n926 Q=regfile[22][14] D=n2986
+ CKN=clk_i__L3_N15
Xregfile_reg[22][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n991
+ SE=FE_OFN102_test_se_i RN=FE_OFN152_n4480 QN=n927 Q=regfile[22][13] D=n2984
+ CKN=clk_i__L3_N15
Xregfile_reg[22][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_38_NET SI=n927
+ SE=FE_OFN102_test_se_i RN=FE_OFN152_n4480 QN=n928 Q=regfile[22][12] D=n2982
+ CKN=clk_i__L3_N15
Xregfile_reg[22][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n939
+ SE=FE_OFN83_test_se_i RN=n4480 QN=n929 Q=regfile[22][11] D=n2980
+ CKN=clk_i__L3_N26
Xregfile_reg[22][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n994
+ SE=FE_OFN83_test_se_i RN=n4480 QN=n930 Q=regfile[22][10] D=n2978
+ CKN=clk_i__L3_N27
Xregfile_reg[22][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n1003
+ SE=FE_OFN88_test_se_i RN=n4480 QN=n931 Q=regfile[22][9] D=n2976
+ CKN=clk_i__L3_N26
Xregfile_reg[22][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n995
+ SE=FE_OFN88_test_se_i RN=n4480 QN=n932 Q=regfile[22][8] D=n2974
+ CKN=clk_i__L3_N26
Xregfile_reg[22][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n901
+ SE=FE_OFN87_test_se_i RN=n4480 QN=n933 Q=regfile[22][7] D=n2972
+ CKN=clk_i__L3_N7
Xregfile_reg[22][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_93_NET SI=n935
+ SE=FE_OFN89_test_se_i RN=n4480 QN=n934 Q=regfile[22][6] D=n2970
+ CKN=clk_i__L3_N7
Xregfile_reg[22][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n904
+ SE=FE_OFN87_test_se_i RN=n4480 QN=n935 Q=regfile[22][5] D=n2968
+ CKN=clk_i__L3_N7
Xregfile_reg[22][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n902
+ SE=FE_OFN87_test_se_i RN=n4480 QN=n936 Q=regfile[22][4] D=n2966
+ CKN=clk_i__L3_N7
Xregfile_reg[22][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_88_NET SI=n905
+ SE=FE_OFN88_test_se_i RN=n4480 QN=n937 Q=regfile[22][3] D=n2964
+ CKN=clk_i__L3_N7
Xregfile_reg[22][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n900
+ SE=FE_OFN88_test_se_i RN=n4480 QN=n938 Q=regfile[22][2] D=n2962
+ CKN=clk_i__L3_N26
Xregfile_reg[22][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n964
+ SE=FE_OFN86_test_se_i RN=n4480 QN=n939 Q=regfile[22][1] D=n2960
+ CKN=clk_i__L3_N26
Xregfile_reg[22][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_66_NET SI=n930
+ SE=FE_OFN83_test_se_i RN=n4480 QN=n940 Q=regfile[22][0] D=n2958
+ CKN=clk_i__L3_N27
Xregfile_reg[18][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n845
+ SE=FE_OFN82_test_se_i RN=n4489 QN=n1037 Q=regfile[18][31] D=n2764
+ CKN=clk_i__L3_N12
Xregfile_reg[18][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_56_NET SI=n1069
+ SE=FE_OFN82_test_se_i RN=n4489 QN=n1038 Q=regfile[18][30] D=n2762
+ CKN=clk_i__L3_N12
Xregfile_reg[18][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n751
+ SE=FE_OFN75_test_se_i RN=FE_OFN149_n4489 QN=n1039 Q=regfile[18][29] D=n2760
+ CKN=clk_i__L3_N12
Xregfile_reg[18][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n1041
+ SE=FE_OFN75_test_se_i RN=FE_OFN149_n4489 QN=n1040 Q=regfile[18][28] D=n2758
+ CKN=clk_i__L3_N12
Xregfile_reg[18][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1101
+ SE=FE_OFN92_test_se_i RN=FE_OFN149_n4489 QN=n1041 Q=regfile[18][27] D=n2756
+ CKN=clk_i__L3_N12
Xregfile_reg[18][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n1106
+ SE=FE_OFN75_test_se_i RN=FE_OFN149_n4489 QN=n1042 Q=regfile[18][26] D=n2754
+ CKN=clk_i__L3_N12
Xregfile_reg[18][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n979
+ SE=FE_OFN77_test_se_i RN=FE_OFN149_n4489 QN=n1043 Q=regfile[18][25] D=n2752
+ CKN=clk_i__L3_N15
Xregfile_reg[18][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1076
+ SE=FE_OFN82_test_se_i RN=n4489 QN=n1044 Q=regfile[18][24] D=n2750
+ CKN=clk_i__L3_N6
Xregfile_reg[18][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_16_NET SI=n1077
+ SE=FE_OFN61_test_se_i RN=FE_OFN149_n4489 QN=n1045 Q=regfile[18][23] D=n2748
+ CKN=clk
Xregfile_reg[18][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n853
+ SE=FE_OFN61_test_se_i RN=FE_OFN149_n4489 QN=n1046 Q=regfile[18][22] D=n2746
+ CKN=clk
Xregfile_reg[18][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n1048
+ SE=FE_OFN62_test_se_i RN=FE_OFN149_n4489 QN=n1047 Q=regfile[18][21] D=n2744
+ CKN=clk_i__L3_N1
Xregfile_reg[18][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_1_NET SI=n1079
+ SE=FE_OFN62_test_se_i RN=FE_OFN149_n4489 QN=n1048 Q=regfile[18][20] D=n2742
+ CKN=clk_i__L3_N1
Xregfile_reg[18][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n919
+ SE=FE_OFN66_test_se_i RN=FE_OFN149_n4489 QN=n1049 Q=regfile[18][19] D=n2740
+ CKN=clk_i__L3_N1
Xregfile_reg[18][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n1052
+ SE=FE_OFN62_test_se_i RN=FE_OFN149_n4489 QN=n1050 Q=regfile[18][18] D=n2738
+ CKN=clk_i__L3_N1
Xregfile_reg[18][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n1081
+ SE=FE_OFN66_test_se_i RN=FE_OFN149_n4489 QN=n1051 Q=regfile[18][17] D=n2736
+ CKN=clk
Xregfile_reg[18][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_NET SI=n1047
+ SE=FE_OFN62_test_se_i RN=FE_OFN149_n4489 QN=n1052 Q=regfile[18][16] D=n2734
+ CKN=clk_i__L3_N1
Xregfile_reg[18][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1075
+ SE=FE_OFN77_test_se_i RN=FE_OFN149_n4489 QN=n1053 Q=regfile[18][15] D=n2732
+ CKN=clk_i__L3_N15
Xregfile_reg[18][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n766
+ SE=FE_OFN76_test_se_i RN=FE_OFN149_n4489 QN=n1054 Q=regfile[18][14] D=n2730
+ CKN=clk
Xregfile_reg[18][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n1023
+ SE=FE_OFN77_test_se_i RN=FE_OFN150_n4488 QN=n1055 Q=regfile[18][13] D=n2728
+ CKN=clk_i__L3_N15
Xregfile_reg[18][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n847
+ SE=FE_OFN75_test_se_i RN=FE_OFN150_n4488 QN=n1056 Q=regfile[18][12] D=n2726
+ CKN=clk_i__L3_N12
Xregfile_reg[18][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n1026
+ SE=FE_OFN86_test_se_i RN=n4488 QN=n1057 Q=regfile[18][11] D=n2724
+ CKN=clk_i__L3_N6
Xregfile_reg[18][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1012
+ SE=FE_OFN86_test_se_i RN=n4488 QN=n1058 Q=regfile[18][10] D=n2722
+ CKN=clk_i__L3_N6
Xregfile_reg[18][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1060
+ SE=FE_OFN113_test_se_i RN=n4488 QN=n1059 Q=regfile[18][9] D=n2720
+ CKN=clk_i__L3_N6
Xregfile_reg[18][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_79_NET SI=n1124
+ SE=FE_OFN113_test_se_i RN=n4488 QN=n1060 Q=regfile[18][8] D=n2718
+ CKN=clk_i__L3_N6
Xregfile_reg[18][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_90_NET SI=n1033
+ SE=FE_OFN87_test_se_i RN=n4488 QN=n1061 Q=regfile[18][7] D=n2716
+ CKN=clk_i__L3_N8
Xregfile_reg[18][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n1064
+ SE=FE_OFN112_test_se_i RN=n4488 QN=n1062 Q=regfile[18][6] D=n2714
+ CKN=clk_i__L3_N7
Xregfile_reg[18][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n871
+ SE=FE_OFN112_test_se_i RN=n4488 QN=n1063 Q=regfile[18][5] D=n2712
+ CKN=clk_i__L3_N8
Xregfile_reg[18][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_97_NET SI=n1096
+ SE=FE_OFN112_test_se_i RN=n4488 QN=n1064 Q=regfile[18][4] D=n2710
+ CKN=clk_i__L3_N8
Xregfile_reg[18][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1098
+ SE=FE_OFN113_test_se_i RN=n4488 QN=n1065 Q=regfile[18][3] D=n2708
+ CKN=clk_i__L3_N8
Xregfile_reg[18][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n965
+ SE=FE_OFN113_test_se_i RN=n4488 QN=n1066 Q=regfile[18][2] D=n2706
+ CKN=clk_i__L3_N8
Xregfile_reg[18][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_72_NET SI=n1121
+ SE=FE_OFN85_test_se_i RN=n4488 QN=n1067 Q=regfile[18][1] D=n2704
+ CKN=clk_i__L3_N6
Xregfile_reg[18][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_70_NET SI=n1057
+ SE=FE_OFN85_test_se_i RN=n4488 QN=n1068 Q=regfile[18][0] D=n2702
+ CKN=clk_i__L3_N6
Xregfile_reg[14][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n1204
+ SE=FE_OFN81_test_se_i RN=n4493 QN=n1165 Q=regfile[14][31] D=n2508
+ CKN=clk_i__L3_N23
Xregfile_reg[14][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1294
+ SE=FE_OFN57_test_se_i RN=n4493 QN=n1166 Q=regfile[14][30] D=n2506
+ CKN=clk_i__L3_N23
Xregfile_reg[14][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1263
+ SE=FE_OFN71_test_se_i RN=n4493 QN=n1167 Q=regfile[14][29] D=n2504
+ CKN=clk_i__L3_N14
Xregfile_reg[14][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n1136
+ SE=FE_OFN92_test_se_i RN=n4493 QN=n1168 Q=regfile[14][28] D=n2502
+ CKN=clk_i__L3_N14
Xregfile_reg[14][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1233
+ SE=FE_OFN92_test_se_i RN=n4493 QN=n1169 Q=regfile[14][27] D=n2500
+ CKN=clk_i__L3_N23
Xregfile_reg[14][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1198
+ SE=FE_OFN92_test_se_i RN=n4493 QN=n1170 Q=regfile[14][26] D=n2498
+ CKN=clk_i__L3_N14
Xregfile_reg[14][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n1138
+ SE=FE_OFN70_test_se_i RN=n4493 QN=n1171 Q=regfile[14][25] D=n2496
+ CKN=clk_i__L3_N14
Xregfile_reg[14][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1236
+ SE=FE_OFN81_test_se_i RN=n4493 QN=n1172 Q=regfile[14][24] D=n2494
+ CKN=clk_i__L3_N23
Xregfile_reg[14][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1141
+ SE=FE_OFN63_test_se_i RN=n4493 QN=n1173 Q=regfile[14][23] D=n2492
+ CKN=clk_i__L3_N5
Xregfile_reg[14][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_24_NET SI=n1206
+ SE=FE_OFN70_test_se_i RN=n4493 QN=n1174 Q=regfile[14][22] D=n2490
+ CKN=clk_i__L3_N5
Xregfile_reg[14][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_8_NET SI=n1208
+ SE=FE_OFN66_test_se_i RN=n4493 QN=n1175 Q=regfile[14][21] D=n2488
+ CKN=clk_i__L3_N4
Xregfile_reg[14][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n857
+ SE=FE_OFN63_test_se_i RN=n4493 QN=n1176 Q=regfile[14][20] D=n2486
+ CKN=clk_i__L3_N4
Xregfile_reg[14][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_9_NET SI=n1399
+ SE=FE_OFN66_test_se_i RN=n4493 QN=n1177 Q=regfile[14][19] D=n2484
+ CKN=clk_i__L3_N4
Xregfile_reg[14][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1180
+ SE=FE_OFN64_test_se_i RN=n4493 QN=n1178 Q=regfile[14][18] D=n2482
+ CKN=clk_i__L3_N5
Xregfile_reg[14][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n1178
+ SE=FE_OFN64_test_se_i RN=n4493 QN=n1179 Q=regfile[14][17] D=n2480
+ CKN=clk_i__L3_N4
Xregfile_reg[14][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n1461
+ SE=FE_OFN64_test_se_i RN=n4493 QN=n1180 Q=regfile[14][16] D=n2478
+ CKN=clk_i__L3_N5
Xregfile_reg[14][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_31_NET SI=n1375
+ SE=FE_OFN1_test_se_i RN=n4494 QN=n1181 Q=regfile[14][15] D=n2476
+ CKN=clk_i__L3_N18
Xregfile_reg[14][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_28_NET SI=n1341
+ SE=FE_OFN22_test_se_i RN=n4494 QN=n1182 Q=regfile[14][14] D=n2474
+ CKN=clk_i__L3_N18
Xregfile_reg[14][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_32_NET SI=n1215
+ SE=FE_OFN69_test_se_i RN=n4494 QN=n1183 Q=regfile[14][13] D=n2472
+ CKN=clk_i__L3_N18
Xregfile_reg[14][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n1216
+ SE=FE_OFN74_test_se_i RN=n4494 QN=n1184 Q=regfile[14][12] D=n2470
+ CKN=clk_i__L3_N18
Xregfile_reg[14][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1281
+ SE=FE_OFN115_test_se_i RN=n4494 QN=n1185 Q=regfile[14][11] D=n2468
+ CKN=clk_i__L3_N20
Xregfile_reg[14][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n1250
+ SE=FE_OFN115_test_se_i RN=n4494 QN=n1186 Q=regfile[14][10] D=n2466
+ CKN=clk_i__L3_N20
Xregfile_reg[14][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_74_NET SI=n1347
+ SE=FE_OFN80_test_se_i RN=n4494 QN=n1187 Q=regfile[14][9] D=n2464
+ CKN=clk_i__L3_N20
Xregfile_reg[14][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n1252
+ SE=FE_OFN80_test_se_i RN=n4494 QN=n1188 Q=regfile[14][8] D=n2462
+ CKN=clk_i__L3_N20
Xregfile_reg[14][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1190
+ SE=FE_OFN12_test_se_i RN=n4494 QN=n1189 Q=regfile[14][7] D=n2460
+ CKN=clk_i__L3_N21
Xregfile_reg[14][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n1254
+ SE=FE_OFN12_test_se_i RN=n4494 QN=n1190 Q=regfile[14][6] D=n2458
+ CKN=clk_i__L3_N21
Xregfile_reg[14][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_96_NET SI=n1158
+ SE=FE_OFN79_test_se_i RN=n4494 QN=n1191 Q=regfile[14][5] D=n2456
+ CKN=clk_i__L3_N21
Xregfile_reg[14][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_95_NET SI=n1352
+ SE=FE_OFN12_test_se_i RN=n4494 QN=n1192 Q=regfile[14][4] D=n2454
+ CKN=clk_i__L3_N8
Xregfile_reg[14][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n1225
+ SE=FE_OFN12_test_se_i RN=n4494 QN=n1193 Q=regfile[14][3] D=n2452
+ CKN=clk_i__L3_N8
Xregfile_reg[14][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n809
+ SE=FE_OFN91_test_se_i RN=n4494 QN=n1194 Q=regfile[14][2] D=n2450
+ CKN=clk_i__L3_N22
Xregfile_reg[14][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n771
+ SE=FE_OFN84_test_se_i RN=n4494 QN=n1195 Q=regfile[14][1] D=n2448
+ CKN=clk_i__L3_N22
Xregfile_reg[14][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_68_NET SI=n1228
+ SE=FE_OFN84_test_se_i RN=n4494 QN=n1196 Q=regfile[14][0] D=n2446
+ CKN=clk_i__L3_N23
Xregfile_reg[10][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_58_NET SI=n1262
+ SE=FE_OFN57_test_se_i RN=n4500 QN=n1293 Q=regfile[10][31] D=n2252
+ CKN=clk_i__L3_N23
Xregfile_reg[10][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1454
+ SE=FE_OFN57_test_se_i RN=n4500 QN=n1294 Q=regfile[10][30] D=n2250
+ CKN=clk_i__L3_N23
Xregfile_reg[10][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1423
+ SE=FE_OFN74_test_se_i RN=n4500 QN=n1295 Q=regfile[10][29] D=n2248
+ CKN=clk_i__L3_N18
Xregfile_reg[10][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n1202
+ SE=FE_OFN58_test_se_i RN=n4500 QN=n1296 Q=regfile[10][28] D=n2246
+ CKN=clk_i__L3_N14
Xregfile_reg[10][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1358
+ SE=FE_OFN58_test_se_i RN=n4500 QN=n1297 Q=regfile[10][27] D=n2244
+ CKN=clk_i__L3_N23
Xregfile_reg[10][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n1264
+ SE=FE_OFN58_test_se_i RN=n4500 QN=n1298 Q=regfile[10][26] D=n2242
+ CKN=clk_i__L3_N14
Xregfile_reg[10][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1203
+ SE=FE_OFN70_test_se_i RN=n4500 QN=n1299 Q=regfile[10][25] D=n2240
+ CKN=clk_i__L3_N14
Xregfile_reg[10][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_62_NET SI=n1268
+ SE=FE_OFN11_test_se_i RN=n4500 QN=n1300 Q=regfile[10][24] D=n2238
+ CKN=clk_i__L3_N23
Xregfile_reg[10][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_18_NET SI=n1145
+ SE=FE_OFN63_test_se_i RN=n4500 QN=n1301 Q=regfile[10][23] D=n2236
+ CKN=clk_i__L3_N5
Xregfile_reg[10][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1238
+ SE=FE_OFN69_test_se_i RN=n4500 QN=n1302 Q=regfile[10][22] D=n2234
+ CKN=clk_i__L3_N5
Xregfile_reg[10][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n1335
+ SE=FE_OFN66_test_se_i RN=n4500 QN=n1303 Q=regfile[10][21] D=n2232
+ CKN=clk_i__L3_N4
Xregfile_reg[10][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n1303
+ SE=FE_OFN66_test_se_i RN=n4500 QN=n1304 Q=regfile[10][20] D=n2230
+ CKN=clk_i__L3_N4
Xregfile_reg[10][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_4_NET SI=n1211
+ SE=FE_OFN17_test_se_i RN=n4500 QN=n1305 Q=regfile[10][19] D=n2228
+ CKN=clk_i__L3_N4
Xregfile_reg[10][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_6_NET SI=n1274
+ SE=FE_OFN65_test_se_i RN=n4500 QN=n1306 Q=regfile[10][18] D=n2226
+ CKN=clk_i__L3_N4
Xregfile_reg[10][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_5_NET SI=n1276
+ SE=FE_OFN55_test_se_i RN=n4501 QN=n1307 Q=regfile[10][17] D=n2224
+ CKN=clk_i__L3_N3
Xregfile_reg[10][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1402
+ SE=FE_OFN55_test_se_i RN=n4501 QN=n1308 Q=regfile[10][16] D=n2222
+ CKN=clk_i__L3_N3
Xregfile_reg[10][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1310
+ SE=FE_OFN76_test_se_i RN=n4501 QN=n1309 Q=regfile[10][15] D=n2220
+ CKN=clk_i__L3_N3
Xregfile_reg[10][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1500
+ SE=FE_OFN76_test_se_i RN=n4501 QN=n1310 Q=regfile[10][14] D=n2218
+ CKN=clk_i__L3_N3
Xregfile_reg[10][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_34_NET SI=n1279
+ SE=FE_OFN1_test_se_i RN=n4501 QN=n1311 Q=regfile[10][13] D=n2216
+ CKN=clk_i__L3_N18
Xregfile_reg[10][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1344
+ SE=FE_OFN7_test_se_i RN=n4501 QN=n1312 Q=regfile[10][12] D=n2214
+ CKN=clk_i__L3_N18
Xregfile_reg[10][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_64_NET SI=n1409
+ SE=FE_OFN3_test_se_i RN=n4501 QN=n1313 Q=regfile[10][11] D=n2212
+ CKN=clk_i__L3_N20
Xregfile_reg[10][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1474
+ SE=FE_OFN114_test_se_i RN=n4501 QN=n1314 Q=regfile[10][10] D=n2210
+ CKN=clk_i__L3_N20
Xregfile_reg[10][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1283
+ SE=FE_OFN114_test_se_i RN=n4501 QN=n1315 Q=regfile[10][9] D=n2208
+ CKN=clk_i__L3_N20
Xregfile_reg[10][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1380
+ SE=FE_OFN111_test_se_i RN=n4501 QN=n1316 Q=regfile[10][8] D=n2206
+ CKN=clk_i__L3_N21
Xregfile_reg[10][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_86_NET SI=n1477
+ SE=FE_OFN111_test_se_i RN=n4501 QN=n1317 Q=regfile[10][7] D=n2204
+ CKN=clk_i__L3_N21
Xregfile_reg[10][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_94_NET SI=n1189
+ SE=FE_OFN12_test_se_i RN=n4501 QN=n1318 Q=regfile[10][6] D=n2202
+ CKN=clk_i__L3_N21
Xregfile_reg[10][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_84_NET SI=n1287
+ SE=FE_OFN78_test_se_i RN=n4501 QN=n1319 Q=regfile[10][5] D=n2200
+ CKN=clk_i__L3_N22
Xregfile_reg[10][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n1321
+ SE=FE_OFN12_test_se_i RN=n4501 QN=n1320 Q=regfile[10][4] D=n2198
+ CKN=clk_i__L3_N8
Xregfile_reg[10][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_91_NET SI=n1161
+ SE=FE_OFN12_test_se_i RN=n4501 QN=n1321 Q=regfile[10][3] D=n2196
+ CKN=clk_i__L3_N8
Xregfile_reg[10][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1354
+ SE=FE_OFN90_test_se_i RN=n4501 QN=n1322 Q=regfile[10][2] D=n2194
+ CKN=clk_i__L3_N22
Xregfile_reg[10][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_77_NET SI=n1355
+ SE=FE_OFN11_test_se_i RN=n4501 QN=n1323 Q=regfile[10][1] D=n2192
+ CKN=clk_i__L3_N22
Xregfile_reg[10][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1291
+ SE=FE_OFN80_test_se_i RN=n4501 QN=n1324 Q=regfile[10][0] D=n2190
+ CKN=clk_i__L3_N22
Xregfile_reg[6][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n1390
+ SE=FE_OFN57_test_se_i RN=n4509 QN=n1421 Q=regfile[6][31] D=n1996
+ CKN=clk_i__L3_N17
Xregfile_reg[6][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_60_NET SI=n1300
+ SE=FE_OFN81_test_se_i RN=n4509 QN=n1422 Q=regfile[6][30] D=n1994
+ CKN=clk_i__L3_N23
Xregfile_reg[6][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1327
+ SE=FE_OFN74_test_se_i RN=FE_OFN162_n4509 QN=n1423 Q=regfile[6][29] D=n1992
+ CKN=clk_i__L3_N18
Xregfile_reg[6][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_49_NET SI=n1392
+ SE=FE_OFN58_test_se_i RN=FE_OFN162_n4509 QN=n1424 Q=regfile[6][28] D=n1990
+ CKN=clk_i__L3_N14
Xregfile_reg[6][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n1489
+ SE=FE_OFN56_test_se_i RN=n4509 QN=n1425 Q=regfile[6][27] D=n1988
+ CKN=clk_i__L3_N17
Xregfile_reg[6][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n1490
+ SE=FE_OFN56_test_se_i RN=FE_OFN162_n4509 QN=n1426 Q=regfile[6][26] D=n1986
+ CKN=clk_i__L3_N17
Xregfile_reg[6][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_36_NET SI=n1183
+ SE=FE_OFN74_test_se_i RN=FE_OFN162_n4509 QN=n1427 Q=regfile[6][25] D=n1984
+ CKN=clk_i__L3_N18
Xregfile_reg[6][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1460
+ SE=FE_OFN115_test_se_i RN=n4509 QN=n1428 Q=regfile[6][24] D=n1982
+ CKN=clk_i__L3_N23
Xregfile_reg[6][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1430
+ SE=FE_OFN17_test_se_i RN=FE_OFN162_n4509 QN=n1429 Q=regfile[6][23] D=n1980
+ CKN=clk_i__L3_N5
Xregfile_reg[6][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_22_NET SI=n1398
+ SE=FE_OFN69_test_se_i RN=FE_OFN162_n4509 QN=n1430 Q=regfile[6][22] D=n1978
+ CKN=clk_i__L3_N5
Xregfile_reg[6][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_11_NET SI=n1464
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1431 Q=regfile[6][21] D=n1976
+ CKN=clk_i__L3_N4
Xregfile_reg[6][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_13_NET SI=n1463
+ SE=FE_OFN64_test_se_i RN=FE_OFN162_n4509 QN=n1432 Q=regfile[6][20] D=n1974
+ CKN=clk_i__L3_N5
Xregfile_reg[6][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1497
+ SE=FE_OFN55_test_se_i RN=FE_OFN160_n4513 QN=n1433 Q=regfile[6][19] D=n1972
+ CKN=clk_i__L3_N3
Xregfile_reg[6][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n1589
+ SE=FE_OFN54_test_se_i RN=FE_OFN160_n4513 QN=n1434 Q=regfile[6][18] D=n1970
+ CKN=clk_i__L3_N3
Xregfile_reg[6][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1466
+ SE=FE_OFN64_test_se_i RN=FE_OFN160_n4513 QN=n1435 Q=regfile[6][17] D=n1968
+ CKN=clk_i__L3_N3
Xregfile_reg[6][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1404
+ SE=FE_OFN54_test_se_i RN=FE_OFN160_n4513 QN=n1436 Q=regfile[6][16] D=n1966
+ CKN=clk_i__L3_N3
Xregfile_reg[6][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n1406
+ SE=FE_OFN76_test_se_i RN=FE_OFN160_n4513 QN=n1437 Q=regfile[6][15] D=n1964
+ CKN=clk_i__L3_N19
Xregfile_reg[6][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1596
+ SE=FE_OFN76_test_se_i RN=FE_OFN160_n4513 QN=n1438 Q=regfile[6][14] D=n1962
+ CKN=clk_i__L3_N19
Xregfile_reg[6][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1470
+ SE=FE_OFN4_test_se_i RN=FE_OFN160_n4513 QN=n1439 Q=regfile[6][13] D=n1960
+ CKN=clk_i__L3_N19
Xregfile_reg[6][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1312
+ SE=FE_OFN4_test_se_i RN=n4513 QN=n1440 Q=regfile[6][12] D=n1958
+ CKN=clk_i__L3_N18
Xregfile_reg[6][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1505
+ SE=FE_OFN3_test_se_i RN=n4513 QN=n1441 Q=regfile[6][11] D=n1956
+ CKN=clk_i__L3_N17
Xregfile_reg[6][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1765
+ SE=FE_OFN114_test_se_i RN=n4513 QN=n1442 Q=regfile[6][10] D=n1954
+ CKN=clk_i__L3_N20
Xregfile_reg[6][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1475
+ SE=FE_OFN114_test_se_i RN=n4513 QN=n1443 Q=regfile[6][9] D=n1952
+ CKN=clk_i__L3_N20
Xregfile_reg[6][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1285
+ SE=FE_OFN111_test_se_i RN=n4513 QN=n1444 Q=regfile[6][8] D=n1950
+ CKN=clk_i__L3_N21
Xregfile_reg[6][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1606
+ SE=FE_OFN78_test_se_i RN=n4513 QN=n1445 Q=regfile[6][7] D=n1948
+ CKN=clk_i__L3_N21
Xregfile_reg[6][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n1478
+ SE=FE_OFN12_test_se_i RN=n4513 QN=n1446 Q=regfile[6][6] D=n1946
+ CKN=clk_i__L3_N21
Xregfile_reg[6][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_89_NET SI=n1479
+ SE=FE_OFN79_test_se_i RN=n4513 QN=n1447 Q=regfile[6][5] D=n1944
+ CKN=clk_i__L3_N21
Xregfile_reg[6][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_92_NET SI=n1512
+ SE=FE_OFN79_test_se_i RN=n4513 QN=n1448 Q=regfile[6][4] D=n1942
+ CKN=clk_i__L3_N21
Xregfile_reg[6][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1447
+ SE=FE_OFN79_test_se_i RN=n4513 QN=n1449 Q=regfile[6][3] D=n1940
+ CKN=clk_i__L3_N22
Xregfile_reg[6][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n1514
+ SE=FE_OFN78_test_se_i RN=n4513 QN=n1450 Q=regfile[6][2] D=n1938
+ CKN=clk_i__L3_N22
Xregfile_reg[6][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_75_NET SI=n1515
+ SE=FE_OFN80_test_se_i RN=n4509 QN=n1451 Q=regfile[6][1] D=n1936
+ CKN=clk_i__L3_N20
Xregfile_reg[6][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1218
+ SE=FE_OFN115_test_se_i RN=n4509 QN=n1452 Q=regfile[6][0] D=n1934
+ CKN=clk_i__L3_N20
Xregfile_reg[3][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1581
+ SE=FE_OFN116_test_se_i RN=n4512 QN=n1517 Q=regfile[3][31] D=n1804
+ CKN=clk_i__L3_N17
Xregfile_reg[3][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n1783
+ SE=FE_OFN56_test_se_i RN=n4512 QN=n1518 Q=regfile[3][30] D=n1802
+ CKN=clk_i__L3_N17
Xregfile_reg[3][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n1520
+ SE=FE_OFN56_test_se_i RN=n4512 QN=n1519 Q=regfile[3][29] D=n1800
+ CKN=clk_i__L3_N17
Xregfile_reg[3][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n1584
+ SE=FE_OFN56_test_se_i RN=n4512 QN=n1520 Q=regfile[3][28] D=n1798
+ CKN=clk_i__L3_N17
Xregfile_reg[3][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n1586
+ SE=FE_OFN5_test_se_i RN=n4512 QN=n1521 Q=regfile[3][27] D=n1796
+ CKN=clk_i__L3_N17
Xregfile_reg[3][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n4570
+ SE=FE_OFN5_test_se_i RN=n4512 QN=n1522 Q=regfile[3][26] D=n1794
+ CKN=clk_i__L3_N17
Xregfile_reg[3][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1408
+ SE=FE_OFN53_test_se_i RN=FE_OFN160_n4513 QN=n1523 Q=regfile[3][25] D=n1792
+ CKN=clk_i__L3_N19
Xregfile_reg[3][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET SI=n1602
+ SE=FE_OFN114_test_se_i RN=n4513 QN=n1524 Q=regfile[3][24] D=n1790
+ CKN=clk_i__L3_N20
Xregfile_reg[3][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_25_NET SI=n1533
+ SE=FE_OFN54_test_se_i RN=FE_OFN160_n4513 QN=n1526 Q=regfile[3][22] D=n1786
+ CKN=clk_i__L3_N19
Xregfile_reg[3][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1528
+ SE=FE_OFN55_test_se_i RN=FE_OFN160_n4513 QN=n1527 Q=regfile[3][21] D=n1784
+ CKN=clk_i__L3_N3
Xregfile_reg[3][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n4565
+ SE=FE_OFN54_test_se_i RN=FE_OFN160_n4513 QN=n1533 Q=regfile[3][15] D=n1772
+ CKN=clk_i__L3_N19
Xregfile_reg[3][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=SPCASCAN_N30
+ SE=FE_OFN53_test_se_i RN=FE_OFN160_n4513 QN=n1534 Q=regfile[3][14] D=n1770
+ CKN=clk_i__L3_N19
Xregfile_reg[3][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=SPCBSCAN_N42
+ SE=FE_OFN53_test_se_i RN=FE_OFN160_n4513 QN=n1535 Q=regfile[3][13] D=n1768
+ CKN=clk_i__L3_N19
Xregfile_reg[3][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n4555
+ SE=FE_OFN4_test_se_i RN=FE_OFN160_n4513 QN=SPCASCAN_N33 Q=regfile[3][12]
+ D=n1766 CKN=clk_i__L3_N19
Xregfile_reg[3][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1767
+ SE=FE_OFN114_test_se_i RN=n4513 QN=n1537 Q=regfile[3][11] D=n1764
+ CKN=clk_i__L3_N16
Xregfile_reg[3][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1548 SE=test_se
+ RN=n4513 QN=n1539 Q=regfile[3][9] D=n1760 CKN=clk_i__L3_N20
Xregfile_reg[3][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_69_NET SI=n1757 SE=test_se
+ RN=n4513 QN=n1540 Q=regfile[3][8] D=n1758 CKN=clk_i__L3_N20
Xregfile_reg[3][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1542
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1543 Q=regfile[3][5] D=n1752
+ CKN=clk_i__L3_N21
Xregfile_reg[3][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1769 SE=test_se
+ RN=FE_OFN164_n4517 QN=n1547 Q=regfile[3][1] D=n1744 CKN=clk_i__L3_N20
Xregfile_reg[1][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n4542
+ SE=FE_OFN116_test_se_i RN=FE_OFN153_n4477 QN=n1581 Q=regfile[1][31] D=n1676
+ CKN=clk_i__L3_N17
Xregfile_reg[1][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n1473
+ SE=FE_OFN56_test_se_i RN=FE_OFN153_n4477 QN=n1582 Q=regfile[1][30] D=n1674
+ CKN=clk_i__L3_N17
Xregfile_reg[1][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_40_NET SI=n1522
+ SE=FE_OFN4_test_se_i RN=FE_OFN153_n4477 QN=n1583 Q=regfile[1][29] D=n1672
+ CKN=clk_i__L3_N19
Xregfile_reg[1][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_47_NET SI=n1521
+ SE=FE_OFN5_test_se_i RN=FE_OFN153_n4477 QN=n1584 Q=regfile[1][28] D=n1670
+ CKN=clk_i__L3_N17
Xregfile_reg[1][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1517
+ SE=FE_OFN5_test_se_i RN=FE_OFN153_n4477 QN=n1585 Q=regfile[1][27] D=n1668
+ CKN=clk_i__L3_N17
Xregfile_reg[1][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_46_NET SI=n4566
+ SE=FE_OFN5_test_se_i RN=FE_OFN153_n4477 QN=n1586 Q=regfile[1][26] D=n1666
+ CKN=clk_i__L3_N17
Xregfile_reg[1][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=n1523
+ SE=FE_OFN1_test_se_i RN=FE_OFN153_n4477 QN=n1587 Q=regfile[1][25] D=n1664
+ CKN=clk_i__L3_N19
Xregfile_reg[1][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1524
+ SE=FE_OFN114_test_se_i RN=FE_OFN153_n4477 QN=n1588 Q=regfile[1][24] D=n1662
+ CKN=clk_i__L3_N17
Xregfile_reg[1][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1309
+ SE=FE_OFN54_test_se_i RN=FE_OFN153_n4477 QN=n1589 Q=regfile[1][23] D=n1660
+ CKN=clk_i__L3_N3
Xregfile_reg[1][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1597
+ SE=FE_OFN54_test_se_i RN=FE_OFN153_n4477 QN=n1590 Q=regfile[1][22] D=n1658
+ CKN=clk_i__L3_N3
Xregfile_reg[1][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1308
+ SE=FE_OFN55_test_se_i RN=FE_OFN153_n4477 QN=n1591 Q=regfile[1][21] D=n1656
+ CKN=clk_i__L3_N3
Xregfile_reg[1][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1595
+ SE=FE_OFN55_test_se_i RN=FE_OFN153_n4477 QN=n1592 Q=regfile[1][20] D=n1654
+ CKN=clk_i__L3_N3
Xregfile_reg[1][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_7_NET SI=n1592
+ SE=FE_OFN55_test_se_i RN=FE_OFN153_n4477 QN=n1593 Q=regfile[1][19] D=n1652
+ CKN=clk_i__L3_N3
Xregfile_reg[1][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1433
+ SE=FE_OFN55_test_se_i RN=FE_OFN153_n4477 QN=n1594 Q=regfile[1][18] D=n1650
+ CKN=clk_i__L3_N3
Xregfile_reg[1][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_10_NET SI=n1530
+ SE=FE_OFN55_test_se_i RN=n4517 QN=n1595 Q=regfile[1][17] D=n1648
+ CKN=clk_i__L3_N3
Xregfile_reg[1][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n1434
+ SE=FE_OFN54_test_se_i RN=n4517 QN=n1596 Q=regfile[1][16] D=n1646
+ CKN=clk_i__L3_N3
Xregfile_reg[1][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n1598
+ SE=FE_OFN76_test_se_i RN=n4517 QN=n1597 Q=regfile[1][15] D=n1644
+ CKN=clk_i__L3_N19
Xregfile_reg[1][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1587
+ SE=FE_OFN53_test_se_i RN=n4517 QN=n1598 Q=regfile[1][14] D=n1642
+ CKN=clk_i__L3_N19
Xregfile_reg[1][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1583
+ SE=FE_OFN4_test_se_i RN=n4517 QN=n1599 Q=regfile[1][13] D=n1640
+ CKN=clk_i__L3_N19
Xregfile_reg[1][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_39_NET SI=n1599
+ SE=FE_OFN4_test_se_i RN=n4517 QN=n1600 Q=regfile[1][12] D=n1638
+ CKN=clk_i__L3_N19
Xregfile_reg[1][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_61_NET SI=n1537
+ SE=FE_OFN116_test_se_i RN=FE_OFN164_n4517 QN=n1601 Q=regfile[1][11] D=n1636
+ CKN=clk_i__L3_N16
Xregfile_reg[1][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_65_NET SI=n1773
+ SE=FE_OFN114_test_se_i RN=FE_OFN164_n4517 QN=n1602 Q=regfile[1][10] D=n1634
+ CKN=clk_i__L3_N20
Xregfile_reg[1][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1611
+ SE=FE_OFN114_test_se_i RN=FE_OFN164_n4517 QN=n1603 Q=regfile[1][9] D=n1632
+ CKN=clk_i__L3_N20
Xregfile_reg[1][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_71_NET SI=n1540
+ SE=FE_OFN114_test_se_i RN=FE_OFN164_n4517 QN=n1604 Q=regfile[1][8] D=n1630
+ CKN=clk_i__L3_N20
Xregfile_reg[1][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n1444
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1605 Q=regfile[1][7] D=n1628
+ CKN=clk_i__L3_N21
Xregfile_reg[1][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1763
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1606 Q=regfile[1][6] D=n1626
+ CKN=clk_i__L3_N21
Xregfile_reg[1][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_80_NET SI=n1605
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1607 Q=regfile[1][5] D=n1624
+ CKN=clk_i__L3_N21
Xregfile_reg[1][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_87_NET SI=n1445
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1608 Q=regfile[1][4] D=n1622
+ CKN=clk_i__L3_N21
Xregfile_reg[1][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=regfile[3][3]
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1609 Q=regfile[1][3] D=n1620
+ CKN=clk_i__L3_N20
Xregfile_reg[1][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n1543
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1610 Q=regfile[1][2] D=n1618
+ CKN=clk_i__L3_N21
Xregfile_reg[1][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_73_NET SI=n1547
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1611 Q=regfile[1][1] D=n1616
+ CKN=clk_i__L3_N20
Xregfile_reg[1][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1539 SE=test_se
+ RN=FE_OFN164_n4517 QN=n1612 Q=regfile[1][0] D=n1614 CKN=clk_i__L3_N20
XEX_reg[2] SDFFRXL $PINS SI=n640 SE=FE_OFN23_test_se_i RN=n4462 QN=n639 Q=n1943
+ D=n3607 CK=clk_i__L3_N9
XImmediate_SE_reg[1] SDFFRXL $PINS SI=n39 SE=FE_OFN23_test_se_i
+ RN=FE_OFN148_n4462 QN=n612 Q=n1951 D=n142 CK=clk_i__L3_N24
XRData2_reg[16] SDFFRXL $PINS SI=FE_PT1_ICACHE_addr_i_30_
+ SE=FE_OFN101_test_se_i RN=n4458 QN=n1667 Q=RData2[16] D=next_RData2[16]
+ CK=clk_i__L3_N2
XRData2_reg[4] SDFFRXL $PINS SI=n1649 SE=FE_OFN108_test_se_i RN=n4459 QN=n1665
+ Q=RData2[4] D=next_RData2[4] CK=clk_i__L3_N10
XRData2_reg[14] SDFFRXL $PINS SI=n71 SE=FE_OFN93_test_se_i RN=n4458 QN=n1663
+ Q=RData2[14] D=next_RData2[14] CK=clk_i__L3_N2
XRData2_reg[0] SDFFRXL $PINS SI=n1617 SE=FE_OFN14_test_se_i RN=n4459 QN=n1661
+ Q=RData2[0] D=next_RData2[0] CK=clk_i__L3_N10
XRData2_reg[12] SDFFRXL $PINS SI=n1655 SE=FE_OFN93_test_se_i RN=n4458 QN=n1659
+ Q=RData2[12] D=next_RData2[12] CK=clk_i__L3_N13
XRData2_reg[1] SDFFRXL $PINS SI=n84 SE=FE_OFN14_test_se_i RN=n4459 QN=n1657
+ Q=RData2[1] D=next_RData2[1] CK=clk_i__L3_N10
XRData2_reg[15] SDFFRXL $PINS SI=n1663 SE=FE_OFN93_test_se_i RN=n4458 QN=n1655
+ Q=RData2[15] D=next_RData2[15] CK=clk_i__L3_N2
XRData2_reg[5] SDFFRXL $PINS SI=n1639 SE=FE_OFN108_test_se_i RN=n4459 QN=n1653
+ Q=RData2[5] D=next_RData2[5] CK=clk_i__L3_N27
XRData2_reg[7] SDFFRXL $PINS SI=n1653 SE=FE_OFN108_test_se_i RN=n4459 QN=n1651
+ Q=RData2[7] D=next_RData2[7] CK=clk_i__L3_N27
XRData2_reg[6] SDFFRXL $PINS SI=n46 SE=FE_OFN108_test_se_i RN=n4459 QN=n1649
+ Q=RData2[6] D=next_RData2[6] CK=clk_i__L3_N27
XRData2_reg[3] SDFFRXL $PINS SI=n1665 SE=FE_OFN14_test_se_i RN=n4459 QN=n1647
+ Q=RData2[3] D=next_RData2[3] CK=clk_i__L3_N10
XRData2_reg[2] SDFFRXL $PINS SI=n1647 SE=FE_OFN14_test_se_i RN=n4459 QN=n1645
+ Q=RData2[2] D=next_RData2[2] CK=clk_i__L3_N10
XRData2_reg[10] SDFFRXL $PINS SI=n70 SE=FE_OFN15_test_se_i RN=n4458 QN=n1643
+ Q=RData2[10] D=next_RData2[10] CK=clk_i__L3_N13
XRData2_reg[13] SDFFRXL $PINS SI=n1619 SE=FE_OFN93_test_se_i RN=n4458 QN=n1641
+ Q=RData2[13] D=next_RData2[13] CK=clk_i__L3_N10
XRData2_reg[8] SDFFRXL $PINS SI=n1637 SE=FE_OFN73_test_se_i RN=n4459 QN=n1639
+ Q=RData2[8] D=next_RData2[8] CK=clk_i__L3_N13
XRData2_reg[9] SDFFRXL $PINS SI=n1627 SE=FE_OFN73_test_se_i RN=n4459 QN=n1637
+ Q=RData2[9] D=next_RData2[9] CK=clk_i__L3_N13
XRData1_reg[0] SDFFRXL $PINS SI=n40 SE=FE_OFN108_test_se_i RN=n4457
+ QN=SPCASCAN_N4 Q=RData1[0] D=next_RData1[0] CK=clk_i__L3_N27
XRData1_reg[8] SDFFRXL $PINS SI=n45 SE=FE_OFN108_test_se_i RN=n4457 QN=n1633
+ Q=RData1[8] D=next_RData1[8] CK=clk_i__L3_N27
XRData1_reg[4] SDFFRXL $PINS SI=n69 SE=FE_OFN108_test_se_i RN=n4457 QN=n1631
+ Q=RData1[4] D=next_RData1[4] CK=clk_i__L3_N27
XRData1_reg[10] SDFFRXL $PINS SI=n28 SE=FE_OFN108_test_se_i RN=n4457 QN=n1629
+ Q=RData1[10] D=next_RData1[10] CK=clk_i__L3_N27
XRData1_reg[12] SDFFRXL $PINS SI=n1643 SE=FE_OFN15_test_se_i RN=FE_OFN146_n4457
+ QN=n1627 Q=RData1[12] D=next_RData1[12] CK=clk_i__L3_N10
XRData1_reg[14] SDFFRXL $PINS SI=n1641 SE=FE_OFN93_test_se_i RN=FE_OFN147_n4455
+ QN=n1625 Q=RData1[14] D=next_RData1[14] CK=clk_i__L3_N10
XRData2_reg[25] SDFFRXL $PINS SI=n77 SE=FE_OFN93_test_se_i RN=FE_OFN146_n4457
+ QN=n1623 Q=RData2[25] D=next_RData2[25] CK=clk_i__L3_N10
XRData2_reg[24] SDFFRXL $PINS SI=n49 SE=FE_OFN93_test_se_i RN=FE_OFN146_n4457
+ QN=n1621 Q=RData2[24] D=next_RData2[24] CK=clk_i__L3_N10
XRData2_reg[11] SDFFRXL $PINS SI=n1659 SE=FE_OFN15_test_se_i RN=n4458 QN=n1619
+ Q=RData2[11] D=next_RData2[11] CK=clk_i__L3_N13
XRData1_reg[31] SDFFRXL $PINS SI=n1615 SE=FE_OFN14_test_se_i RN=n4457 QN=n1617
+ Q=RData1[31] D=next_RData1[31] CK=clk_i__L3_N10
XRData1_reg[30] SDFFRXL $PINS SI=n1645 SE=FE_OFN14_test_se_i RN=n4457 QN=n1615
+ Q=RData1[30] D=next_RData1[30] CK=clk_i__L3_N10
XRData1_reg[29] SDFFRXL $PINS SI=n101 SE=FE_OFN14_test_se_i RN=FE_OFN147_n4455
+ QN=n1613 Q=RData1[29] D=next_RData1[29] CK=clk_i__L3_N10
XRData1_reg[28] SDFFRXL $PINS SI=n1657 SE=FE_OFN14_test_se_i RN=n4457 QN=n101
+ Q=RData1[28] D=next_RData1[28] CK=clk_i__L3_N10
XRData1_reg[27] SDFFRXL $PINS SI=n1661 SE=FE_OFN14_test_se_i RN=n4457 QN=n84
+ Q=RData1[27] D=next_RData1[27] CK=clk_i__L3_N10
XRData2_reg[29] SDFFRXL $PINS SI=n80 SE=FE_OFN96_test_se_i RN=FE_OFN146_n4457
+ QN=n82 Q=RData2[29] D=next_RData2[29] CK=clk_i__L3_N10
XRData2_reg[28] SDFFRXL $PINS SI=n64 SE=FE_OFN96_test_se_i RN=FE_OFN146_n4457
+ QN=n81 Q=RData2[28] D=next_RData2[28] CK=clk_i__L3_N10
XRData1_reg[26] SDFFRXL $PINS SI=n1613 SE=FE_OFN96_test_se_i RN=FE_OFN147_n4455
+ QN=n80 Q=RData1[26] D=next_RData1[26] CK=clk_i__L3_N10
XRData1_reg[23] SDFFRXL $PINS SI=n1621 SE=FE_OFN93_test_se_i RN=FE_OFN147_n4455
+ QN=n79 Q=RData1[23] D=next_RData1[23] CK=clk_i__L3_N10
XRData1_reg[21] SDFFRXL $PINS SI=n48 SE=FE_OFN94_test_se_i RN=FE_OFN147_n4455
+ QN=n78 Q=RData1[21] D=next_RData1[21] CK=clk_i__L3_N11
XRData1_reg[19] SDFFRXL $PINS SI=n78 SE=FE_OFN93_test_se_i RN=FE_OFN147_n4455
+ QN=n77 Q=RData1[19] D=next_RData1[19] CK=clk_i__L3_N10
XRData1_reg[18] SDFFRXL $PINS SI=n74 SE=FE_OFN94_test_se_i RN=FE_OFN147_n4455
+ QN=n75 Q=RData1[18] D=next_RData1[18] CK=clk_i__L3_N11
XRData1_reg[17] SDFFRXL $PINS SI=n56 SE=FE_OFN94_test_se_i RN=FE_OFN147_n4455
+ QN=n74 Q=RData1[17] D=next_RData1[17] CK=clk_i__L3_N11
XRData1_reg[16] SDFFRXL $PINS SI=n55 SE=FE_OFN94_test_se_i RN=FE_OFN147_n4455
+ QN=n72 Q=RData1[16] D=next_RData1[16] CK=clk_i__L3_N2
XRData1_reg[15] SDFFRXL $PINS SI=n52 SE=FE_OFN93_test_se_i RN=FE_OFN147_n4455
+ QN=n71 Q=RData1[15] D=next_RData1[15] CK=clk_i__L3_N2
XRData1_reg[13] SDFFRXL $PINS SI=n1625 SE=FE_OFN15_test_se_i RN=FE_OFN146_n4457
+ QN=n70 Q=RData1[13] D=next_RData1[13] CK=clk_i__L3_N13
XRData1_reg[5] SDFFRXL $PINS SI=n43 SE=FE_OFN108_test_se_i RN=n4457 QN=n69
+ Q=RData1[5] D=next_RData1[5] CK=clk_i__L3_N27
XRData1_reg[2] SDFFRXL $PINS SI=n41 SE=FE_OFN108_test_se_i RN=n4457 QN=n68
+ Q=RData1[2] D=next_RData1[2] CK=clk_i__L3_N27
XRData2_reg[31] SDFFRXL $PINS SI=n81 SE=FE_OFN96_test_se_i RN=FE_OFN146_n4457
+ QN=n67 Q=RData2[31] D=next_RData2[31] CK=clk_i__L3_N10
XRData2_reg[30] SDFFRXL $PINS SI=n82 SE=FE_OFN96_test_se_i RN=FE_OFN146_n4457
+ QN=n64 Q=RData2[30] D=next_RData2[30] CK=clk_i__L3_N10
XRData2_reg[27] SDFFRXL $PINS SI=n42 SE=FE_OFN96_test_se_i RN=FE_OFN146_n4457
+ QN=n63 Q=RData2[27] D=next_RData2[27] CK=clk_i__L3_N10
XRData2_reg[26] SDFFRXL $PINS SI=n63 SE=FE_OFN96_test_se_i RN=FE_OFN146_n4457
+ QN=n60 Q=RData2[26] D=next_RData2[26] CK=clk_i__L3_N10
XRData2_reg[23] SDFFRXL $PINS SI=n58 SE=FE_OFN93_test_se_i RN=FE_OFN146_n4457
+ QN=n59 Q=RData2[23] D=next_RData2[23] CK=clk_i__L3_N2
XRData2_reg[22] SDFFRXL $PINS SI=n79 SE=FE_OFN93_test_se_i RN=FE_OFN146_n4457
+ QN=n58 Q=RData2[22] D=next_RData2[22] CK=clk_i__L3_N10
XRData2_reg[21] SDFFRXL $PINS SI=n72 SE=FE_OFN94_test_se_i RN=n4458 QN=n56
+ Q=RData2[21] D=next_RData2[21] CK=clk_i__L3_N2
XRData2_reg[20] SDFFRXL $PINS SI=n51 SE=FE_OFN94_test_se_i RN=n4458 QN=n55
+ Q=RData2[20] D=next_RData2[20] CK=clk_i__L3_N2
XRData2_reg[19] SDFFRXL $PINS SI=n59 SE=FE_OFN93_test_se_i RN=n4458 QN=n52
+ Q=RData2[19] D=next_RData2[19] CK=clk_i__L3_N10
XRData2_reg[18] SDFFRXL $PINS SI=n50 SE=FE_OFN101_test_se_i RN=n4458 QN=n51
+ Q=RData2[18] D=next_RData2[18] CK=clk_i__L3_N2
XRData2_reg[17] SDFFRXL $PINS SI=n1667 SE=FE_OFN101_test_se_i RN=n4458 QN=n50
+ Q=RData2[17] D=next_RData2[17] CK=clk_i__L3_N2
XRData1_reg[25] SDFFRXL $PINS SI=n60 SE=FE_OFN96_test_se_i RN=FE_OFN147_n4455
+ QN=n49 Q=RData1[25] D=next_RData1[25] CK=clk_i__L3_N10
XRData1_reg[22] SDFFRXL $PINS SI=n47 SE=FE_OFN94_test_se_i RN=FE_OFN147_n4455
+ QN=n48 Q=RData1[22] D=next_RData1[22] CK=clk_i__L3_N11
XRData1_reg[20] SDFFRXL $PINS SI=n75 SE=FE_OFN94_test_se_i RN=FE_OFN147_n4455
+ QN=n47 Q=RData1[20] D=next_RData1[20] CK=clk_i__L3_N11
XRData1_reg[11] SDFFRXL $PINS SI=n1651 SE=FE_OFN108_test_se_i RN=n4457 QN=n46
+ Q=RData1[11] D=next_RData1[11] CK=clk_i__L3_N27
XRData1_reg[9] SDFFRXL $PINS SI=n1629 SE=FE_OFN108_test_se_i RN=n4457 QN=n45
+ Q=RData1[9] D=next_RData1[9] CK=clk_i__L3_N27
XRData1_reg[7] SDFFRXL $PINS SI=n1633 SE=FE_OFN108_test_se_i RN=n4457 QN=n44
+ Q=RData1[7] D=next_RData1[7] CK=clk_i__L3_N27
XRData1_reg[6] SDFFRXL $PINS SI=n44 SE=FE_OFN108_test_se_i RN=n4457 QN=n43
+ Q=RData1[6] D=next_RData1[6] CK=clk_i__L3_N27
XRData1_reg[24] SDFFRXL $PINS SI=n1623 SE=FE_OFN93_test_se_i RN=FE_OFN147_n4455
+ QN=n42 Q=RData1[24] D=next_RData1[24] CK=clk_i__L3_N10
XRData1_reg[3] SDFFRXL $PINS SI=n1631 SE=FE_OFN108_test_se_i RN=n4457 QN=n41
+ Q=RData1[3] D=next_RData1[3] CK=clk_i__L3_N27
XRData1_reg[1] SDFFRXL $PINS SI=n68 SE=FE_OFN108_test_se_i RN=n4457 QN=n40
+ Q=RData1[1] D=next_RData1[1] CK=clk_i__L3_N27
Xregfile_reg[3][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_78_NET SI=n1541
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1546 Q=regfile[3][2] D=n1746
+ CKN=clk_i__L3_N20
XImmediate_SE_reg[5] SDFFRXL $PINS SI=n601 SE=FE_OFN105_test_se_i
+ RN=FE_OFN148_n4462 QN=n626 Q=n1947 D=n146 CK=clk_i__L3_N24
XImmediate_SE_reg[2] SDFFRXL $PINS SI=n626 SE=FE_OFN23_test_se_i
+ RN=FE_OFN148_n4462 QN=n39 Q=n1949 D=n143 CK=clk_i__L3_N24
Xregfile_reg[3][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_85_NET SI=n1771
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1542 Q=regfile[3][6] D=n1754
+ CKN=clk_i__L3_N21
Xregfile_reg[3][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n4559
+ SE=FE_OFN55_test_se_i RN=FE_OFN160_n4513 QN=n1531 Q=regfile[3][17] D=n1776
+ CKN=clk_i__L3_N3
Xregfile_reg[3][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1525
+ SE=FE_OFN54_test_se_i RN=FE_OFN160_n4513 QN=n1532 Q=regfile[3][16] D=n1774
+ CKN=clk_i__L3_N3
XRegisterRs_reg[1] SDFFRXL $PINS SI=n651 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n649 Q=RegisterRs[1] D=n3622 CK=clk_i__L3_N9
Xregfile_reg[3][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_63_NET
+ SI=FE_PT1_ICACHE_addr_i_17_ SE=FE_OFN114_test_se_i RN=n4513 QN=n1538 Q=n88
+ D=n1762 CKN=clk_i__L3_N20
Xregfile_reg[2][29] SDFFNSRXL $PINS SN=LTIE_LTIEHI_43_NET SI=n4554
+ SE=FE_OFN4_test_se_i RN=n4517 QN=n1551 Q=n4571 D=n1736 CKN=clk_i__L3_N17
Xregfile_reg[2][28] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n4569
+ SE=FE_OFN5_test_se_i RN=n4517 QN=n1552 Q=n4570 D=n1734 CKN=clk_i__L3_N17
Xregfile_reg[2][26] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=SPCASCAN_N34
+ SE=FE_OFN5_test_se_i RN=n4517 QN=n1554 Q=n4568 D=n1730 CKN=clk_i__L3_N16
Xregfile_reg[2][31] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n4552
+ SE=FE_OFN5_test_se_i RN=n4517 QN=n1549 Q=n4573 D=n1740 CKN=clk_i__L3_N16
Xregfile_reg[2][30] SDFFNSRXL $PINS SN=LTIE_LTIEHI_48_NET SI=n4573
+ SE=FE_OFN5_test_se_i RN=n4517 QN=n1550 Q=SPCASCAN_N35 D=n1738 CKN=clk_i__L3_N17
Xregfile_reg[2][27] SDFFNSRXL $PINS SN=LTIE_LTIEHI_50_NET SI=n4553
+ SE=FE_OFN5_test_se_i RN=n4517 QN=n1553 Q=n4569 D=n1732 CKN=clk_i__L3_N17
Xregfile_reg[2][9] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n4549
+ SE=FE_OFN116_test_se_i RN=FE_OFN155_n4473 QN=n1571 Q=n4551 D=n1696
+ CKN=clk_i__L3_N16
Xregfile_reg[2][25] SDFFNSRXL $PINS SN=LTIE_LTIEHI_35_NET SI=n1535
+ SE=FE_OFN53_test_se_i RN=n4517 QN=n1555 Q=SPCBSCAN_N41 D=n1728
+ CKN=clk_i__L3_N19
Xregfile_reg[2][10] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=SPCASCAN_N36
+ SE=FE_OFN5_test_se_i RN=FE_OFN155_n4473 QN=n1570 Q=n4552 D=n1698
+ CKN=clk_i__L3_N16
Xregfile_reg[2][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n4548
+ SE=FE_OFN116_test_se_i RN=FE_OFN155_n4473 QN=n1573 Q=n4549 D=n1692
+ CKN=clk_i__L3_N17
Xregfile_reg[2][6] SDFFNSRXL $PINS SN=LTIE_LTIEHI_55_NET SI=n4550
+ SE=FE_OFN116_test_se_i RN=FE_OFN155_n4473 QN=n1574 Q=n4548 D=n1690
+ CKN=clk_i__L3_N17
Xregfile_reg[2][5] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n1518
+ SE=FE_OFN116_test_se_i RN=FE_OFN155_n4473 QN=n1575 Q=n4547 D=n1688
+ CKN=clk_i__L3_N17
Xregfile_reg[2][2] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n1601
+ SE=FE_OFN116_test_se_i RN=FE_OFN153_n4477 QN=n1578 Q=n4544 D=n1682
+ CKN=clk_i__L3_N16
Xregfile_reg[2][15] SDFFNSRXL $PINS SN=LTIE_LTIEHI_29_NET SI=n1534
+ SE=FE_OFN53_test_se_i RN=FE_OFN155_n4473 QN=n1565 Q=n4557 D=n1708
+ CKN=clk_i__L3_N19
Xregfile_reg[2][12] SDFFNSRXL $PINS SN=LTIE_LTIEHI_44_NET SI=n4568
+ SE=FE_OFN4_test_se_i RN=FE_OFN155_n4473 QN=n1568 Q=n4554 D=n1702
+ CKN=clk_i__L3_N17
Xregfile_reg[2][8] SDFFNSRXL $PINS SN=LTIE_LTIEHI_54_NET SI=n1585
+ SE=FE_OFN5_test_se_i RN=FE_OFN155_n4473 QN=n1572 Q=n4550 D=n1694
+ CKN=clk_i__L3_N17
Xregfile_reg[2][24] SDFFNSRXL $PINS SN=LTIE_LTIEHI_42_NET SI=n4571
+ SE=FE_OFN4_test_se_i RN=n4517 QN=n1556 Q=n4566 D=n1726 CKN=clk_i__L3_N17
Xregfile_reg[2][14] SDFFNSRXL $PINS SN=LTIE_LTIEHI_33_NET SI=SPCASCAN_N32
+ SE=FE_OFN53_test_se_i RN=FE_OFN155_n4473 QN=n1566 Q=SPCASCAN_N31 D=n1706
+ CKN=clk_i__L3_N19
Xregfile_reg[2][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n4547
+ SE=FE_OFN116_test_se_i RN=FE_OFN155_n4473 QN=n1576 Q=n4546 D=n1686
+ CKN=clk_i__L3_N16
Xregfile_reg[2][1] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n4544
+ SE=FE_OFN116_test_se_i RN=FE_OFN153_n4477 QN=n1579 Q=n4543 D=n1680
+ CKN=clk_i__L3_N16
Xregfile_reg[2][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_57_NET SI=n4546
+ SE=FE_OFN116_test_se_i RN=FE_OFN153_n4477 QN=n1577 Q=SPCASCAN_N37 D=n1684
+ CKN=clk_i__L3_N16
Xregfile_reg[2][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_27_NET SI=n4557
+ SE=FE_OFN54_test_se_i RN=n4517 QN=n1557 Q=n4565 D=n1724 CKN=clk_i__L3_N19
Xregfile_reg[2][22] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n4563
+ SE=FE_OFN54_test_se_i RN=n4517 QN=n1558 Q=n4564 D=n1722 CKN=clk_i__L3_N3
Xregfile_reg[2][21] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n4558
+ SE=FE_OFN54_test_se_i RN=FE_OFN155_n4473 QN=n1559 Q=n4563 D=n1720
+ CKN=clk_i__L3_N3
Xregfile_reg[2][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n4561
+ SE=FE_OFN54_test_se_i RN=FE_OFN155_n4473 QN=n1560 Q=n4562 D=n1718
+ CKN=clk_i__L3_N3
Xregfile_reg[2][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n4564
+ SE=FE_OFN54_test_se_i RN=FE_OFN155_n4473 QN=n1561 Q=n4561 D=n1716
+ CKN=clk_i__L3_N3
Xregfile_reg[2][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_19_NET SI=n4562
+ SE=FE_OFN54_test_se_i RN=FE_OFN155_n4473 QN=n1562 Q=n4560 D=n1714
+ CKN=clk_i__L3_N3
Xregfile_reg[2][17] SDFFNSRXL $PINS SN=LTIE_LTIEHI_17_NET SI=n4560
+ SE=FE_OFN55_test_se_i RN=FE_OFN155_n4473 QN=n1563 Q=n4559 D=n1712
+ CKN=clk_i__L3_N3
Xregfile_reg[2][16] SDFFNSRXL $PINS SN=LTIE_LTIEHI_21_NET SI=n1532
+ SE=FE_OFN54_test_se_i RN=FE_OFN155_n4473 QN=n1564 Q=n4558 D=n1710
+ CKN=clk_i__L3_N3
Xregfile_reg[2][13] SDFFNSRXL $PINS SN=LTIE_LTIEHI_37_NET SI=n1600
+ SE=FE_OFN4_test_se_i RN=FE_OFN155_n4473 QN=n1567 Q=n4555 D=n1704
+ CKN=clk_i__L3_N19
Xregfile_reg[2][11] SDFFNSRXL $PINS SN=LTIE_LTIEHI_52_NET SI=n4551
+ SE=FE_OFN5_test_se_i RN=FE_OFN155_n4473 QN=n1569 Q=n4553 D=n1700
+ CKN=clk_i__L3_N17
Xregfile_reg[2][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_59_NET SI=n4543
+ SE=FE_OFN116_test_se_i RN=FE_OFN153_n4477 QN=n1580 Q=n4542 D=n1678
+ CKN=clk_i__L3_N17
XPCBuffer_reg[31] SDFFRXL $PINS SI=n26 SE=FE_OFN72_test_se_i RN=rst QN=n3626
+ Q=n4639 D=n3587 CK=clk_i__L3_N27
XEX_reg[0] SDFFRXL $PINS SI=n37 SE=FE_OFN23_test_se_i RN=n4462 QN=n38 Q=EX[0]
+ D=n3605 CK=clk_i__L3_N24
XEX_reg[4] SDFFRXL $PINS SI=SPCASCAN_N18 SE=FE_OFN23_test_se_i RN=n4462 QN=n37
+ Q=n1941 D=n3609 CK=clk_i__L3_N24
XRegisterRs_reg[0] SDFFRXL $PINS SI=n647 SE=FE_OFN110_test_se_i RN=n4462
+ QN=n648 Q=RegisterRs[0] D=n3621 CK=clk_i__L3_N9
XRegisterRs_reg[3] SDFFRXL $PINS SI=n634 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n651 Q=RegisterRs[3] D=n3624 CK=clk_i__L3_N9
XRegisterRs_reg[2] SDFFRXL $PINS SI=n652 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n650 Q=RegisterRs[2] D=n3623 CK=clk_i__L3_N9
XRegisterRt_reg[1] SDFFRXL $PINS SI=n643 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n644 Q=RegisterRt[1] D=n3617 CK=clk_i__L3_N9
XRegisterRt_reg[4] SDFFRXL $PINS SI=n631 SE=FE_OFN110_test_se_i RN=n4462
+ QN=n647 Q=RegisterRt[4] D=n3620 CK=clk_i__L3_N9
XRegisterRt_reg[2] SDFFRXL $PINS SI=SPCASCAN_N20 SE=FE_OFN23_test_se_i
+ RN=FE_OFN148_n4462 QN=SPCASCAN_N19 Q=RegisterRt[2] D=n3618 CK=clk_i__L3_N24
XRegisterRt_reg[3] SDFFRXL $PINS SI=n650 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n646 Q=RegisterRt[3] D=n3619 CK=clk_i__L3_N9
XRegisterRt_reg[0] SDFFRXL $PINS SI=n632 SE=FE_OFN110_test_se_i
+ RN=FE_OFN148_n4462 QN=n643 Q=RegisterRt[0] D=n3616 CK=clk_i__L3_N9
XImmediate_SE_reg[20] SDFFRXL $PINS SI=n611 SE=FE_OFN96_test_se_i RN=n4460
+ QN=n613 Q=Immediate_SE[20] D=next_Immediate_SE[20] CK=clk_i__L3_N11
XImmediate_SE_reg[25] SDFFRXL $PINS SI=n610 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n618 Q=Immediate_SE[25] D=next_Immediate_SE[25] CK=clk_i__L3_N9
XImmediate_SE_reg[24] SDFFRXL $PINS SI=n608 SE=FE_OFN97_test_se_i RN=n4460
+ QN=n617 Q=Immediate_SE[24] D=next_Immediate_SE[24] CK=clk_i__L3_N11
Xregfile_reg[3][7] SDFFNSRXL $PINS SN=LTIE_LTIEHI_81_NET SI=n1544
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1541 Q=n89 D=n1756
+ CKN=clk_i__L3_N21
Xregfile_reg[3][4] SDFFNSRXL $PINS SN=LTIE_LTIEHI_83_NET SI=n1759
+ SE=FE_OFN111_test_se_i RN=FE_OFN164_n4517 QN=n1544 Q=n90 D=n1750
+ CKN=clk_i__L3_N21
Xregfile_reg[3][3] SDFFNSRXL $PINS SN=LTIE_LTIEHI_76_NET SI=n1546 SE=test_se
+ RN=FE_OFN164_n4517 QN=n1545 Q=regfile[3][3] D=n1748 CKN=clk_i__L3_N20
Xregfile_reg[3][23] SDFFNSRXL $PINS SN=LTIE_LTIEHI_23_NET SI=n1526
+ SE=FE_OFN54_test_se_i RN=FE_OFN160_n4513 QN=n1525 Q=n87 D=n1788
+ CKN=clk_i__L3_N3
Xregfile_reg[3][20] SDFFNSRXL $PINS SN=LTIE_LTIEHI_14_NET SI=n1531
+ SE=FE_OFN55_test_se_i RN=FE_OFN160_n4513 QN=n1528 Q=n85 D=n1782
+ CKN=clk_i__L3_N3
Xregfile_reg[3][19] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1527
+ SE=FE_OFN55_test_se_i RN=FE_OFN160_n4513 QN=n1529 Q=n94 D=n1780
+ CKN=clk_i__L3_N3
Xregfile_reg[3][18] SDFFNSRXL $PINS SN=LTIE_LTIEHI_12_NET SI=n1529
+ SE=FE_OFN55_test_se_i RN=FE_OFN160_n4513 QN=n1530 Q=n91 D=n1778
+ CKN=clk_i__L3_N3
Xregfile_reg[3][0] SDFFNSRXL $PINS SN=LTIE_LTIEHI_67_NET SI=n1895 SE=test_se
+ RN=FE_OFN164_n4517 QN=n1548 Q=n92 D=n1742 CKN=clk_i__L3_N20
XU1 INVXL $PINS Y=n1757 A=regfile[1][0]
XU2 INVXL $PINS Y=n1759 A=regfile[1][2]
XU3 INVXL $PINS Y=n1763 A=regfile[1][5]
XU4 INVXL $PINS Y=n1765 A=regfile[1][8]
XU10 INVXL $PINS Y=n1767 A=regfile[1][24]
XU13 INVXL $PINS Y=n1769 A=regfile[1][3]
XU31 INVXL $PINS Y=n1771 A=regfile[1][4]
XU32 INVXL $PINS Y=n1773 A=regfile[1][9]
XU34 INVXL $PINS Y=n1775 A=regfile[1][19]
XU36 INVXL $PINS Y=n1783 A=regfile[1][30]
XU37 MXI2X1 $PINS Y=n519 S0=n1857 B=n1553 A=n516
XU39 NOR2BX1 $PINS Y=n4199 B=n4270 AN=n1601
XU40 AND2X2 $PINS Y=n4134 B=n1588 A=n4424
XU41 AOI221XL $PINS Y=n1785 C0=n1789 B1=n1889 B0=next_RData1[3]
+ A1=EX_RegWriteData[3] A0=n1891
XU42 INVX1 $PINS Y=n4948 A=n1785
XU47 INVX1 $PINS Y=n1789 A=n4940
XU88 MXI2X1 $PINS Y=n4165 S0=n1863 B=n1562 A=n4162
XU89 NOR2BX1 $PINS Y=n630 B=FE_OFN217_n3742 AN=n1596
XU90 NAND4X1 $PINS Y=n4979 D=n4928 C=n4929 B=n4930 A=n1791
XU91 XOR2X1 $PINS Y=n1791 B=n4899 A=n1801
XU92 CLKBUFX3 $PINS Y=n1793 A=n4643
XU93 AND2X2 $PINS Y=n1795 B=equal A=Branch
XU94 AOI221XL $PINS Y=n1797 C0=n1799 B1=n1889 B0=next_RData1[14]
+ A1=EX_RegWriteData[14] A0=n1891
XU95 INVX1 $PINS Y=n4821 A=n1797
XU96 INVX1 $PINS Y=n1799 A=n4813
XU97 AND2X2 $PINS Y=n4254 B=n1612 A=n4424
XU98 AND3X2 $PINS Y=n1801 C=n4892 B=n96 A=n95
XU99 AND2X2 $PINS Y=n3719 B=n1610 A=n1803
XU100 INVX1 $PINS Y=n1803 A=n3746
XU101 CLKMX2X2 $PINS Y=N148 S0=n4257 B=n1805 A=n1807
XU102 MXI4X1 $PINS Y=n1805 S1=n4265 S0=N25 D=n4089 C=n4091 B=n4090 A=n4092
XU103 MXI4X1 $PINS Y=n1807 S1=n4265 S0=N25 D=n4093 C=n4095 B=n4094 A=n4096
XU104 AND2X2 $PINS Y=n4209 B=n1809 A=n1603
XU105 INVX1 $PINS Y=n1809 A=n4280
XU106 OR2X1 $PINS Y=n1811 B=n4243 A=n4244
XU107 INVX1 $PINS Y=n4246 A=n1811
XU108 AOI221XL $PINS Y=n1813 C0=n1815 B1=n1889 B0=next_RData1[4]
+ A1=EX_RegWriteData[4] A0=n1891
XU109 INVX1 $PINS Y=n4918 A=n1813
XU110 INVX1 $PINS Y=n1815 A=n4910
XU111 MXI2X1 $PINS Y=n4175 S0=n1863 B=n1564 A=n4172
XU112 MXI2X1 $PINS Y=n1755 S0=n1857 B=n1571 A=n1741
XU113 AOI221XL $PINS Y=n1817 C0=n1819 B1=n1889 B0=next_RData1[21]
+ A1=EX_RegWriteData[21] A0=n1891
XU114 INVX1 $PINS Y=n4764 A=n1817
XU115 INVX1 $PINS Y=n1819 A=n4756
XU116 MXI2X1 $PINS Y=N164 S0=n4428 B=n3807 A=n3808
XU117 CLKMX2X2 $PINS Y=N158 S0=n4257 B=n1821 A=n1823
XU118 MXI4X1 $PINS Y=n1821 S1=n4264 S0=n4261 D=n4009 C=n4011 B=n4010 A=n4012
XU119 MXI4X1 $PINS Y=n1823 S1=n4264 S0=n4261 D=n4013 C=n4015 B=n4014 A=n4016
XU120 AND2X2 $PINS Y=n1781 B=n1604 A=n4431
XU121 AND2X2 $PINS Y=n503 B=n1825 A=n1582
XU122 INVX1 $PINS Y=n1825 A=n3748
XU123 MXI2X1 $PINS Y=n4220 S0=n1863 B=n1573 A=n4217
XU124 MXI2X1 $PINS Y=n4190 S0=n1863 B=n1567 A=n4187
XU125 MXI2X1 $PINS Y=n4135 S0=n1863 B=n1556 A=n4132
XU126 AOI221XL $PINS Y=n1827 C0=n1829 B1=n1889 B0=next_RData1[1]
+ A1=EX_RegWriteData[1] A0=n1891
XU127 INVX1 $PINS Y=n4974 A=n1827
XU128 INVX1 $PINS Y=n1829 A=n4960
XU174 MXI2X1 $PINS Y=n3730 S0=n1857 B=n1580 A=n3727
XU236 MXI2X1 $PINS Y=N157 S0=n1893 B=n3821 A=n3822
XU241 AND2X2 $PINS Y=n4159 B=n1831 A=n1593
XU242 INVX1 $PINS Y=n1831 A=n4268
XU249 MXI2X1 $PINS Y=n4255 S0=n1863 B=n1580 A=n4252
XU268 AND2X2 $PINS Y=n4239 B=n1833 A=n1609
XU271 INVX1 $PINS Y=n1833 A=n4270
XU279 MXI2X1 $PINS Y=n3720 S0=n1857 B=n1578 A=n3717
XU280 MXI2X1 $PINS Y=N153 S0=n1893 B=n3829 A=n3830
XU282 MXI2X1 $PINS Y=n4200 S0=n1863 B=n1569 A=n4197
XU283 MXI2X1 $PINS Y=n1677 S0=n1857 B=n1564 A=n628
XU284 AND2X2 $PINS Y=n4234 B=n1835 A=n1608
XU288 INVX1 $PINS Y=n1835 A=n4269
XU293 MXI2X1 $PINS Y=N173 S0=n1893 B=n3789 A=n3790
XU303 MXI2X2 $PINS Y=N178 S0=n1893 B=n3779 A=n3780
XU343 AND2X2 $PINS Y=n4229 B=n1607 A=n4424
XU534 MXI2X1 $PINS Y=n4245 S0=n1863 B=n1578 A=n4242
XU659 CLKMX2X2 $PINS Y=N142 S0=n3732 B=n1837 A=n1839
XU724 MXI4X1 $PINS Y=n1837 S1=n3738 S0=n3734 D=n280 C=n282 B=n281 A=n283
XU879 MXI4X1 $PINS Y=n1839 S1=n3738 S0=n3734 D=n284 C=n286 B=n285 A=n287
XU883 MXI2X1 $PINS Y=N152 S0=n1893 B=n3831 A=n3832
XU884 MXI2X1 $PINS Y=N162 S0=n1893 B=n3811 A=n3812
XU885 CLKMX2X2 $PINS Y=N167 S0=N26 B=n1841 A=n1843
XU886 MXI4X1 $PINS Y=n1841 S1=n4262 S0=n4258 D=n3937 C=n3939 B=n3938 A=n3940
XU887 MXI4X1 $PINS Y=n1843 S1=N24 S0=n4258 D=n3941 C=n3943 B=n3942 A=n3944
XU894 MXI2X1 $PINS Y=n3700 S0=n1857 B=n1574 A=n3697
XU895 CLKMX2X2 $PINS Y=N159 S0=n4257 B=n1845 A=n1847
XU906 MXI4X1 $PINS Y=n1845 S1=n4264 S0=n4261 D=n4001 C=n4003 B=n4002 A=n4004
XU916 MXI4X1 $PINS Y=n1847 S1=n4264 S0=n4261 D=n4005 C=n4007 B=n4006 A=n4008
XU919 MXI2X1 $PINS Y=n4130 S0=n1863 B=n1555 A=n4127
XU920 MXI2X1 $PINS Y=n4215 S0=n1863 B=n1572 A=n4212
XU929 AOI221XL $PINS Y=n1849 C0=n1851 B1=n1889 B0=next_RData1[20]
+ A1=EX_RegWriteData[20] A0=n1891
XU930 INVX1 $PINS Y=n4755 A=n1849
XU931 INVX1 $PINS Y=n1851 A=n4747
XU946 MXI2X1 $PINS Y=n1707 S0=n1857 B=n1567 A=n1701
XU997 MXI2X1 $PINS Y=n1787 S0=n1857 B=n1572 A=n1777
XU998 MXI2X1 $PINS Y=n509 S0=n1857 B=n1551 A=n506
XU1043 MXI2X1 $PINS Y=n4160 S0=n1863 B=n1561 A=n4157
XU1051 AOI221XL $PINS Y=n1853 C0=n1855 B1=n1889 B0=next_RData1[19] A1=n1891
+ A0=EX_RegWriteData[19]
XU1083 INVX1 $PINS Y=n4786 A=n1853
XU1087 OAI22XL $PINS Y=n1855 B1=FE_OFN177_n4400 B0=n4780 A1=n4402 A0=n4781
XU1127 MXI2X1 $PINS Y=n4210 S0=n1863 B=n1571 A=n4207
XU1143 MXI2X1 $PINS Y=N151 S0=n1893 B=n3833 A=n3834
XU1263 MXI2X1 $PINS Y=n4110 S0=n1863 B=n1551 A=n4107
XU1266 MXI2X1 $PINS Y=n524 S0=n1857 B=n1554 A=n521
XU1273 CLKINVX3 $PINS Y=n1857 A=n3774
XU1274 AOI221XL $PINS Y=n1859 C0=n1861 B1=n1889 B0=next_RData1[23]
+ A1=EX_RegWriteData[23] A0=n1891
XU1276 INVX1 $PINS Y=n4746 A=n1859
XU1277 OAI22XL $PINS Y=n1861 B1=n4740 B0=FE_OFN177_n4400 A1=n4741 A0=n4402
XU1279 MXI2X1 $PINS Y=n4235 S0=n1863 B=n1576 A=n4232
XU1281 CLKINVX3 $PINS Y=n1863 A=n4300
XU1283 AOI221XL $PINS Y=n1865 C0=n1867 B1=n1889 B0=next_RData1[22]
+ A1=EX_RegWriteData[22] A0=n1891
XU1284 INVX1 $PINS Y=n4737 A=n1865
XU1285 OAI22XL $PINS Y=n1867 B1=n4731 B0=FE_OFN177_n4400 A1=n4732 A0=n4402
XU1286 AOI221XL $PINS Y=n1869 C0=n1871 B1=n1889 B0=next_RData1[17]
+ A1=EX_RegWriteData[17] A0=n1891
XU1287 INVX1 $PINS Y=n4804 A=n1869
XU1290 OAI22XL $PINS Y=n1871 B1=n4798 B0=FE_OFN177_n4400 A1=n4799 A0=n4402
XU1292 MXI2X1 $PINS Y=n4225 S0=n4423 B=n1574 A=n4222
XU1294 MXI2X1 $PINS Y=n4230 S0=n4423 B=n1575 A=n4227
XU1297 AOI221XL $PINS Y=n1873 C0=n1875 B1=n1889 B0=next_RData1[12]
+ A1=EX_RegWriteData[12] A0=n1891
XU1299 INVX1 $PINS Y=n4839 A=n1873
XU1300 INVX1 $PINS Y=n1875 A=n4831
XU1337 MXI2X1 $PINS Y=N149 S0=n1893 B=n3837 A=n3838
XU1341 AOI221XL $PINS Y=n1877 C0=n1879 B1=n1889 B0=next_RData1[28]
+ A1=EX_RegWriteData[28] A0=n1891
XU1349 INVX1 $PINS Y=n4675 A=n1877
XU1363 OAI22XL $PINS Y=n1879 B1=n4669 B0=FE_OFN177_n4400 A1=n4670
+ A0=FE_OFN178_n4402
XU1369 CLKMX2X2 $PINS Y=N169 S0=N26 B=n1881 A=n1883
XU1370 MXI4X1 $PINS Y=n1881 S1=n4263 S0=n4258 D=n3921 C=n3923 B=n3922 A=n3924
XU1378 MXI4X1 $PINS Y=n1883 S1=n4265 S0=n4426 D=n3925 C=n3927 B=n3926 A=n3928
XU1382 AOI221XL $PINS Y=n1885 C0=n1887 B1=n1889 B0=next_RData1[7]
+ A1=EX_RegWriteData[7] A0=n1891
XU1386 INVX1 $PINS Y=n4909 A=n1885
XU1390 INVX1 $PINS Y=n1887 A=n4901
XU1394 INVX2 $PINS Y=n1889 A=n4404
XU1398 INVX2 $PINS Y=n1891 A=n4406
XU1405 MXI2X1 $PINS Y=N165 S0=n1893 B=n3805 A=n3806
XU1413 CLKINVX3 $PINS Y=n1893 A=N26
XU1425 MXI2X1 $PINS Y=n534 S0=n4430 B=n1556 A=n531
XU1433 MXI2X1 $PINS Y=n504 S0=n4430 B=n1550 A=n501
XU1437 CLKBUFX3 $PINS Y=n1895 A=n1538
XU1457 AND2X2 $PINS Y=n4202 B=n1895 A=n4268
XU1465 INVXL $PINS Y=n1897 A=n3658
XU1473 INVXL $PINS Y=n1899 A=n1897
XU1488 INVXL $PINS Y=SPCASCAN_N2 A=n1897
XU1496 CLKBUFX2 $PINS Y=Immediate_SE[2] A=n1913
XU1500 CLKBUFX2 $PINS Y=Immediate_SE[1] A=n1951
XU1516 CLKBUFX2 $PINS Y=EX[1] A=n1945
XU1528 CLKBUFX2 $PINS Y=EX[2] A=n1943
XU1560 INVXL $PINS Y=n1911 A=n1949
XU1564 INVXL $PINS Y=n1913 A=n1911
XU1686 INVXL $PINS Y=n1929 A=n1947
XU1687 INVX1 $PINS Y=Immediate_SE[5] A=n1929
XU1689 INVXL $PINS Y=n1935 A=n1941
XU1690 INVXL $PINS Y=EX[4] A=n1935
.ENDS

.SUBCKT InstructionFetch_DW01_add_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25]
+ SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16]
+ SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6]
+ SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XU1 AND2X2 $PINS Y=n1 B=n28 A=A[30]
XU2 AND2X2 $PINS Y=n28 B=n27 A=A[29]
XU3 XOR2X1 $PINS Y=SUM[29] B=n27 A=A[29]
XU4 XOR2X1 $PINS Y=SUM[30] B=n28 A=A[30]
XU5 XOR2X1 $PINS Y=SUM[31] B=n1 A=A[31]
XU6 AND2XL $PINS Y=n13 B=n12 A=A[13]
XU7 AND2XL $PINS Y=n15 B=n14 A=A[15]
XU8 AND2XL $PINS Y=n14 B=n13 A=A[14]
XU9 AND2XL $PINS Y=n16 B=n15 A=A[16]
XU10 AND2XL $PINS Y=n17 B=n16 A=A[17]
XU11 AND2XL $PINS Y=n18 B=n17 A=A[18]
XU12 AND2XL $PINS Y=n19 B=n18 A=A[19]
XU13 AND2XL $PINS Y=n20 B=n19 A=A[20]
XU14 AND2XL $PINS Y=n21 B=n20 A=A[21]
XU15 AND2XL $PINS Y=n22 B=n21 A=A[22]
XU16 AND2XL $PINS Y=n23 B=n22 A=A[23]
XU18 AND2XL $PINS Y=n2 B=n24 A=A[25]
XU19 AND2XL $PINS Y=n26 B=n25 A=A[27]
XU20 AND2XL $PINS Y=n25 B=n2 A=A[26]
XU21 AND2XL $PINS Y=n27 B=n26 A=A[28]
XU22 AND2XL $PINS Y=n3 B=A[2] A=A[3]
XU23 AND2XL $PINS Y=n4 B=n3 A=A[4]
XU24 AND2XL $PINS Y=n5 B=n4 A=A[5]
XU25 AND2XL $PINS Y=n6 B=n5 A=A[6]
XU26 AND2XL $PINS Y=n7 B=n6 A=A[7]
XU27 AND2XL $PINS Y=n8 B=n7 A=A[8]
XU28 AND2XL $PINS Y=n9 B=n8 A=A[9]
XU29 AND2XL $PINS Y=n10 B=n9 A=A[10]
XU30 AND2XL $PINS Y=n11 B=n10 A=A[11]
XU31 AND2XL $PINS Y=n12 B=n11 A=A[12]
XU32 XOR2XL $PINS Y=SUM[28] B=n26 A=A[28]
XU33 INVXL $PINS Y=SUM[2] A=A[2]
XU34 XOR2XL $PINS Y=SUM[14] B=n13 A=A[14]
XU35 XOR2XL $PINS Y=SUM[3] B=A[2] A=A[3]
XU36 XOR2XL $PINS Y=SUM[4] B=n3 A=A[4]
XU37 XOR2XL $PINS Y=SUM[6] B=n5 A=A[6]
XU38 XOR2XL $PINS Y=SUM[7] B=n6 A=A[7]
XU39 XOR2XL $PINS Y=SUM[8] B=n7 A=A[8]
XU40 XOR2XL $PINS Y=SUM[9] B=n8 A=A[9]
XU41 XOR2XL $PINS Y=SUM[10] B=n9 A=A[10]
XU42 XOR2XL $PINS Y=SUM[11] B=n10 A=A[11]
XU43 XOR2XL $PINS Y=SUM[12] B=n11 A=A[12]
XU44 XOR2XL $PINS Y=SUM[13] B=n12 A=A[13]
XU45 XOR2XL $PINS Y=SUM[15] B=n14 A=A[15]
XU46 XOR2XL $PINS Y=SUM[16] B=n15 A=A[16]
XU47 XOR2XL $PINS Y=SUM[17] B=n16 A=A[17]
XU48 XOR2XL $PINS Y=SUM[18] B=n17 A=A[18]
XU49 XOR2XL $PINS Y=SUM[19] B=n18 A=A[19]
XU50 XOR2XL $PINS Y=SUM[20] B=n19 A=A[20]
XU51 XOR2XL $PINS Y=SUM[21] B=n20 A=A[21]
XU52 XOR2XL $PINS Y=SUM[22] B=n21 A=A[22]
XU53 XOR2XL $PINS Y=SUM[23] B=n22 A=A[23]
XU54 XOR2XL $PINS Y=SUM[24] B=n23 A=A[24]
XU55 XOR2XL $PINS Y=SUM[25] B=n24 A=A[25]
XU56 XOR2XL $PINS Y=SUM[26] B=n2 A=A[26]
XU57 XOR2XL $PINS Y=SUM[27] B=n25 A=A[27]
XU58 XOR2XL $PINS Y=SUM[5] B=n4 A=A[5]
XU59 CLKBUFX2 $PINS Y=SUM[1] A=A[1]
XU60 CLKBUFX2 $PINS Y=SUM[0] A=A[0]
XU62 AND2X2 $PINS Y=n31 B=A[24] A=n22
XU63 NOR2BX1 $PINS Y=n24 B=n32 AN=A[23]
XU64 INVX1 $PINS Y=n32 A=n31
.ENDS

.SUBCKT InstructionFetch_DW01_add_1 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25]
+ SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16]
+ SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6]
+ SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XU1_16 ADDFXL $PINS S=SUM[16] CO=carry[17] CI=carry[16] B=B[16] A=A[16]
XU1_14 ADDFXL $PINS S=SUM[14] CO=carry[15] CI=carry[14] B=B[14] A=A[14]
XU1_12 ADDFXL $PINS S=SUM[12] CO=carry[13] CI=carry[12] B=B[12] A=A[12]
XU1_10 ADDFXL $PINS S=SUM[10] CO=carry[11] CI=carry[10] B=B[10] A=A[10]
XU1_8 ADDFXL $PINS S=SUM[8] CO=carry[9] CI=carry[8] B=B[8] A=A[8]
XU1_6 ADDFXL $PINS S=SUM[6] CO=carry[7] CI=carry[6] B=B[6] A=A[6]
XU1_4 ADDFXL $PINS S=SUM[4] CO=carry[5] CI=carry[4] B=B[4] A=A[4]
XU1_18 ADDFXL $PINS S=SUM[18] CO=carry[19] CI=carry[18] B=B[18] A=A[18]
XU1_28 ADDFXL $PINS S=SUM[28] CO=carry[29] CI=carry[28] B=B[28] A=A[28]
XU1_3 ADDFXL $PINS S=SUM[3] CO=carry[4] CI=n1 B=B[3] A=A[3]
XU1_13 ADDFXL $PINS S=SUM[13] CO=carry[14] CI=carry[13] B=B[13] A=A[13]
XU1_11 ADDFXL $PINS S=SUM[11] CO=carry[12] CI=carry[11] B=B[11] A=A[11]
XU1_9 ADDFXL $PINS S=SUM[9] CO=carry[10] CI=carry[9] B=B[9] A=A[9]
XU1_7 ADDFXL $PINS S=SUM[7] CO=carry[8] CI=carry[7] B=B[7] A=A[7]
XU1_5 ADDFXL $PINS S=SUM[5] CO=carry[6] CI=carry[5] B=B[5] A=A[5]
XU1_15 ADDFXL $PINS S=SUM[15] CO=carry[16] CI=carry[15] B=B[15] A=A[15]
XU1_25 CMPR32X2 $PINS S=SUM[25] CO=carry[26] C=carry[25] B=B[25] A=A[25]
XU1_17 ADDFXL $PINS S=SUM[17] CO=carry[18] CI=carry[17] B=B[17] A=A[17]
XU1_26 ADDFXL $PINS S=SUM[26] CO=carry[27] CI=carry[26] B=B[26] A=A[26]
XU1_24 ADDFXL $PINS S=SUM[24] CO=carry[25] CI=carry[24] B=B[24] A=A[24]
XU1_22 ADDFXL $PINS S=SUM[22] CO=carry[23] CI=carry[22] B=B[22] A=A[22]
XU1_31 XOR3X1 $PINS Y=SUM[31] C=carry[31] B=B[31] A=A[31]
XU1_27 ADDFXL $PINS S=SUM[27] CO=carry[28] CI=carry[27] B=B[27] A=A[27]
XU1_23 ADDFXL $PINS S=SUM[23] CO=carry[24] CI=carry[23] B=B[23] A=A[23]
XU1_21 ADDFXL $PINS S=SUM[21] CO=carry[22] CI=carry[21] B=B[21] A=A[21]
XU1_29 ADDFXL $PINS S=SUM[29] CO=carry[30] CI=carry[29] B=B[29] A=A[29]
XU1_30 ADDFXL $PINS S=SUM[30] CO=carry[31] CI=carry[30] B=B[30] A=A[30]
XU1_19 ADDFXL $PINS S=SUM[19] CO=carry[20] CI=carry[19] B=B[19] A=A[19]
XU1_20 ADDFXL $PINS S=SUM[20] CO=carry[21] CI=carry[20] B=B[20] A=A[20]
XU1 AND2X2 $PINS Y=n1 B=A[2] A=B[2]
XU2 XOR2XL $PINS Y=SUM[2] B=A[2] A=B[2]
XU3 CLKBUFX3 $PINS Y=SUM[1] A=A[1]
XU4 CLKBUFX3 $PINS Y=SUM[0] A=A[0]
.ENDS

.SUBCKT InstructionFetch_test_1 clk rst stall PCWrite PCJumpJRorBranch[31]
+ PCJumpJRorBranch[30] PCJumpJRorBranch[29] PCJumpJRorBranch[28]
+ PCJumpJRorBranch[27] PCJumpJRorBranch[26] PCJumpJRorBranch[25]
+ PCJumpJRorBranch[24] PCJumpJRorBranch[23] PCJumpJRorBranch[22]
+ PCJumpJRorBranch[21] PCJumpJRorBranch[20] PCJumpJRorBranch[19]
+ PCJumpJRorBranch[18] PCJumpJRorBranch[17] PCJumpJRorBranch[16]
+ PCJumpJRorBranch[15] PCJumpJRorBranch[14] PCJumpJRorBranch[13]
+ PCJumpJRorBranch[12] PCJumpJRorBranch[11] PCJumpJRorBranch[10]
+ PCJumpJRorBranch[9] PCJumpJRorBranch[8] PCJumpJRorBranch[7]
+ PCJumpJRorBranch[6] PCJumpJRorBranch[5] PCJumpJRorBranch[4]
+ PCJumpJRorBranch[3] PCJumpJRorBranch[2] PCJumpJRorBranch[1]
+ PCJumpJRorBranch[0] IF_ID_Write IF_Flush PCadd4[31] PCadd4[30] PCadd4[29]
+ PCadd4[28] PCadd4[27] PCadd4[26] PCadd4[25] PCadd4[24] PCadd4[23] PCadd4[22]
+ PCadd4[21] PCadd4[20] PCadd4[19] PCadd4[18] PCadd4[17] PCadd4[16] PCadd4[15]
+ PCadd4[14] PCadd4[13] PCadd4[12] PCadd4[11] PCadd4[10] PCadd4[9] PCadd4[8]
+ PCadd4[7] PCadd4[6] PCadd4[5] PCadd4[4] PCadd4[3] PCadd4[2] PCadd4[1]
+ PCadd4[0] Instruction[31] Instruction[30] Instruction[29] Instruction[28]
+ Instruction[27] Instruction[26] Instruction[25] Instruction[24]
+ Instruction[23] Instruction[22] Instruction[21] Instruction[20]
+ Instruction[19] Instruction[18] Instruction[17] Instruction[16]
+ Instruction[15] Instruction[14] Instruction[13] Instruction[12]
+ Instruction[11] Instruction[10] Instruction[9] Instruction[8] Instruction[7]
+ Instruction[6] Instruction[5] Instruction[4] Instruction[3] Instruction[2]
+ Instruction[1] Instruction[0] PC[31] PC[30] PC[29] PC[28] PC[27] PC[26]
+ PC[25] PC[24] PC[23] PC[22] PC[21] PC[20] PC[19] PC[18] PC[17] PC[16] PC[15]
+ PC[14] PC[13] PC[12] PC[11] PC[10] PC[9] PC[8] PC[7] PC[6] PC[5] PC[4] PC[3]
+ PC[2] PC[1] PC[0] read_Instruction[31] read_Instruction[30]
+ read_Instruction[29] read_Instruction[28] read_Instruction[27]
+ read_Instruction[26] read_Instruction[25] read_Instruction[24]
+ read_Instruction[23] read_Instruction[22] read_Instruction[21]
+ read_Instruction[20] read_Instruction[19] read_Instruction[18]
+ read_Instruction[17] read_Instruction[16] read_Instruction[15]
+ read_Instruction[14] read_Instruction[13] read_Instruction[12]
+ read_Instruction[11] read_Instruction[10] read_Instruction[9]
+ read_Instruction[8] read_Instruction[7] read_Instruction[6]
+ read_Instruction[5] read_Instruction[4] read_Instruction[3]
+ read_Instruction[2] read_Instruction[1] read_Instruction[0] PredictMiss
+ BranchTaken PCBuffer_valid test_si test_so test_se SPCASCAN_N0 SPCASCAN_N1
+ SPCASCAN_N2 SPCASCAN_N3 SPCASCAN_N4 SPCASCAN_N5 SPCASCAN_N7 SPCASCAN_N9
+ SPCASCAN_N11 SPCASCAN_N13 SPCASCAN_N14 SPCASCAN_N15 SPCASCAN_N18 SPCASCAN_N19
+ SPCASCAN_N20 SPCASCAN_N23 SPCASCAN_N24 SPCASCAN_N25 SPCASCAN_N26 SPCASCAN_N27
+ SPCASCAN_N28 SPCASCAN_N29 test_si_i FE_OFN23_test_se_i FE_OFN8_test_se_i
+ FE_OFN103_test_se_i FE_OFN104_test_se_i FE_OFN105_test_se_i
+ FE_OFN108_test_se_i FE_OFN109_test_se_i clk_i__L3_N25 clk_i__L3_N26
+ clk_i__L3_N27 clk_i__L3_N7 clk_i__L3_N9
XFE_OFC145_n251 CLKBUFX2 $PINS Y=FE_OFN145_n251 A=n251
XFE_OFC144_n249 CLKBUFX3 $PINS Y=FE_OFN144_n249 A=n254
XFE_OFC143_n253 CLKBUFX2 $PINS Y=FE_OFN143_n253 A=n253
XFE_OFC142_n254 CLKBUFX3 $PINS Y=FE_OFN142_n254 A=n254
XFE_OFC123_n237 CLKBUFX2 $PINS Y=FE_OFN123_n237 A=n115
XFE_OFC122_n114 CLKBUFX2 $PINS Y=FE_OFN122_n114 A=n114
XFE_OFC121_n232 CLKBUFX2 $PINS Y=FE_OFN121_n232 A=n232
XFE_OFC120_n233 CLKBUFX2 $PINS Y=FE_OFN120_n233 A=n233
XFE_OFC119_n228 CLKBUFX2 $PINS Y=FE_OFN119_n228 A=n228
XFE_OFC118_n230 CLKBUFX2 $PINS Y=FE_OFN118_n230 A=n278
XFE_OFC117_n239 CLKBUFX2 $PINS Y=FE_OFN117_n239 A=n239
XFE_OFC107_test_se_i CLKBUFX2 $PINS Y=FE_OFN107_test_se_i A=test_se
XFE_OFC49_n37 CLKBUFX2 $PINS Y=FE_OFN49_n37 A=n37
XFE_OFC48_n196 CLKBUFX3 $PINS Y=FE_OFN48_n196 A=n196
XFE_OFC47_n50 CLKBUFX3 $PINS Y=FE_OFN47_n50 A=n50
XFE_OFC46_n192 CLKBUFX2 $PINS Y=FE_OFN46_n192 A=n192
XFE_OFC41_n208 CLKBUFX3 $PINS Y=FE_OFN41_n208 A=n208
XFE_OFC34_n200 CLKBUFX2 $PINS Y=FE_OFN34_n200 A=n200
Xnext_state_reg[1] TLATX1 $PINS Q=next_state[1] G=n232 D=N74
XU3 MXI2X1 $PINS Y=n264 S0=FE_OFN121_n232 B=N54 A=PCadd4[31]
XU4 NAND4BBXL $PINS Y=n125 D=n128 C=n308 BN=read_Instruction[29]
+ AN=read_Instruction[28]
XU5 NOR3X1 $PINS Y=n127 C=read_Instruction[26] B=read_Instruction[27]
+ A=read_Instruction[1]
XU7 NAND2X1 $PINS Y=n129 B=n265 A=n266
XU8 NAND2X1 $PINS Y=n132 B=n274 A=n275
XU9 NAND2X1 $PINS Y=n130 B=n268 A=n269
XU10 NAND2X1 $PINS Y=n131 B=n271 A=n272
XU11 NAND2X1 $PINS Y=n123 B=n279 A=n287
XU12 OAI211X1 $PINS Y=n152 C0=n93 B0=n92 A1=n306 A0=FE_OFN117_n239
XU13 OAI211X1 $PINS Y=n151 C0=n91 B0=n90 A1=n305 A0=FE_OFN117_n239
XU14 OAI211X1 $PINS Y=n150 C0=n89 B0=n88 A1=n304 A0=FE_OFN117_n239
XU15 OAI211X1 $PINS Y=n148 C0=n85 B0=n84 A1=n302 A0=FE_OFN117_n239
XU16 OAI211X1 $PINS Y=n147 C0=n83 B0=n82 A1=n301 A0=FE_OFN117_n239
XU17 OAI211X1 $PINS Y=n146 C0=n81 B0=n80 A1=n300 A0=FE_OFN117_n239
XU18 OAI211X1 $PINS Y=n144 C0=n77 B0=n76 A1=n298 A0=FE_OFN117_n239
XU19 OAI211X1 $PINS Y=n142 C0=n73 B0=n72 A1=n296 A0=n239
XU20 OAI211X1 $PINS Y=n141 C0=n71 B0=n70 A1=n295 A0=n239
XU21 OAI211X1 $PINS Y=n140 C0=n69 B0=n68 A1=n294 A0=n239
XU22 OAI211X1 $PINS Y=n139 C0=n67 B0=n66 A1=n293 A0=n239
XU23 OAI211X1 $PINS Y=n138 C0=n65 B0=n64 A1=n292 A0=n239
XU24 OAI211X1 $PINS Y=n137 C0=n63 B0=n62 A1=n291 A0=n239
XU25 OAI211X1 $PINS Y=n136 C0=n61 B0=n60 A1=n290 A0=n239
XU26 OAI211X1 $PINS Y=n135 C0=n59 B0=n58 A1=n289 A0=n239
XU27 OAI211X1 $PINS Y=n134 C0=n57 B0=n56 A1=n288 A0=n239
XU29 MX2X1 $PINS Y=n2 S0=FE_OFN121_n232 B=N43 A=n568
XU30 MX2X1 $PINS Y=n3 S0=n232 B=N26 A=PCadd4[3]
XU31 MX2XL $PINS Y=n4 S0=FE_OFN121_n232 B=N44 A=n514
XU32 MX2X1 $PINS Y=n5 S0=FE_OFN121_n232 B=N46 A=n538
XU33 MX2X1 $PINS Y=n6 S0=FE_OFN121_n232 B=N47 A=n541
XU34 CLKMX2X2 $PINS Y=n7 S0=FE_OFN121_n232 B=N45 A=n508
XU35 CLKMX2X2 $PINS Y=n9 S0=FE_OFN121_n232 B=N42 A=n559
XU36 CLKMX2X2 $PINS Y=n10 S0=FE_OFN121_n232 B=N40 A=n532
XU37 CLKMX2X2 $PINS Y=n11 S0=FE_OFN121_n232 B=N41 A=n553
XU38 CLKINVX1 $PINS Y=n241 A=n45
XU39 CLKINVX1 $PINS Y=n278 A=n259
XU41 CLKMX2X2 $PINS Y=n14 S0=n232 B=N27 A=PCadd4[4]
XU42 CLKMX2X2 $PINS Y=n15 S0=n232 B=N29 A=PCadd4[6]
XU43 CLKMX2X2 $PINS Y=n16 S0=FE_OFN121_n232 B=N50 A=PCadd4[27]
XU44 CLKMX2X2 $PINS Y=n17 S0=FE_OFN121_n232 B=N48 A=n562
XU45 CLKMX2X2 $PINS Y=n18 S0=FE_OFN121_n232 B=N49 A=n511
XU46 AND4X1 $PINS Y=n19 D=n262 C=n257 B=n236 A=n256
XU47 AND4X1 $PINS Y=N13 D=n122 C=n108 B=n112 A=n121
XU48 AND4X1 $PINS Y=n20 D=n127 C=read_Instruction[3] B=n310 A=PCBuffer_valid
XU50 CLKMX2X2 $PINS Y=n21 S0=n232 B=N30 A=PCadd4[7]
XU51 CLKMX2X2 $PINS Y=n22 S0=n232 B=N32 A=PCadd4[9]
XU52 CLKMX2X2 $PINS Y=n23 S0=n232 B=N34 A=PCadd4[11]
XU53 CLKMX2X2 $PINS Y=n24 S0=n232 B=N33 A=n565
XU54 CLKMX2X2 $PINS Y=n25 S0=n232 B=N31 A=PCadd4[8]
XU55 CLKMX2X2 $PINS Y=n26 S0=n232 B=N35 A=n547
XU56 CLKMX2X2 $PINS Y=n27 S0=FE_OFN121_n232 B=N38 A=n574
XU57 CLKMX2X2 $PINS Y=n28 S0=FE_OFN121_n232 B=N37 A=n550
XU58 CLKMX2X2 $PINS Y=n29 S0=n232 B=N36 A=n529
XU59 CLKMX2X2 $PINS Y=n30 S0=FE_OFN121_n232 B=N39 A=n556
XU61 AND2X2 $PINS Y=n224 B=read_Instruction[15] A=N13
XU62 NAND4BBXL $PINS Y=n120 D=Instruction[28] C=n124 BN=n583 AN=Instruction[26]
XU63 INVX12 $PINS Y=PC[1] A=n32
XU64 INVX12 $PINS Y=PC[0] A=n31
XU65 MXI2X1 $PINS Y=n270 S0=FE_OFN121_n232 B=N52 A=PCadd4[29]
XU67 CLKINVX1 $PINS Y=n284 A=n117
XU68 MXI2X1 $PINS Y=n267 S0=n279 B=N53 A=PCadd4[30]
XU69 INVX12 $PINS Y=PC[31] A=n35
XU70 AO21X1 $PINS Y=n282 B0=n260 A1=FE_OFN119_n228 A0=PCBrPredict[31]
XU71 INVX12 $PINS Y=PC[25] A=FE_OFN49_n37
XU72 INVX12 $PINS Y=PC[27] A=n405
XU73 INVX12 $PINS Y=PC[26] A=n399
XU74 INVX12 $PINS Y=PC[28] A=n402
XU75 INVX12 $PINS Y=PC[29] A=n396
XU76 INVX12 $PINS Y=PC[30] A=n377
XU77 AO21X1 $PINS Y=n283 B0=n261 A1=FE_OFN119_n228 A0=PCBrPredict[30]
XU78 CLKINVX8 $PINS Y=PC[22] A=FE_OFN47_n50
XU79 INVX12 $PINS Y=PC[24] A=n394
XU80 INVX12 $PINS Y=PC[20] A=n54
XU81 INVX12 $PINS Y=PC[10] A=n102
XU82 INVX12 $PINS Y=PC[19] A=n106
XU83 INVX12 $PINS Y=PC[16] A=n126
XU84 INVX12 $PINS Y=PC[11] A=n184
XU85 INVX12 $PINS Y=PC[14] A=n186
XU86 INVX12 $PINS Y=PC[12] A=n188
XU87 INVX12 $PINS Y=PC[18] A=n190
XU88 INVX12 $PINS Y=PC[21] A=FE_OFN46_n192
XU89 INVX12 $PINS Y=PC[17] A=n383
XU90 CLKINVX8 $PINS Y=PC[23] A=FE_OFN48_n196
XU91 INVX12 $PINS Y=PC[9] A=n198
XU92 OAI211X1 $PINS Y=n149 C0=n87 B0=n86 A1=n303 A0=FE_OFN117_n239
XU93 INVX12 $PINS Y=PC[6] A=FE_OFN34_n200
XU94 INVX12 $PINS Y=PC[7] A=n202
XU95 INVX12 $PINS Y=PC[8] A=n204
XU96 INVX12 $PINS Y=PC[13] A=n386
XU97 CLKINVX8 $PINS Y=PC[15] A=FE_OFN41_n208
XU98 INVX1 $PINS Y=n279 A=n286
XU99 CLKBUFX2 $PINS Y=n232 A=n279
XU100 NOR4X1 $PINS Y=n128 D=read_Instruction[30] C=read_Instruction[31]
+ B=read_Instruction[4] A=read_Instruction[5]
XU101 INVX12 $PINS Y=PC[5] A=n210
XU102 INVX12 $PINS Y=PC[4] A=n212
XU103 INVX1 $PINS Y=SPCASCAN_N24 A=n214
XU104 INVX12 $PINS Y=PC[3] A=n216
XU106 AND2X2 $PINS Y=n219 B=FE_OFN118_n230 A=PCJumpJRorBranch[25]
XU107 NAND2X1 $PINS Y=n223 B=n20 A=n222
XU108 AND2XL $PINS Y=n218 B=n319 A=n285
XU109 BUFX2 $PINS Y=n228 A=n19
XU110 CLKMX2X2 $PINS Y=n220 S0=n232 B=N25 A=PCadd4[2]
XU111 OAI2BB2XL $PINS Y=next_BranchTaken B1=n123 B0=n407 A1N=n123
+ A0N=BranchTaken
XU112 NAND2X1 $PINS Y=n286 B=n242 A=n223
XU113 AO22XL $PINS Y=n182 B1=n114 B0=read_Instruction[25] A1=n115
+ A0=Instruction[25]
XU114 NAND3BXL $PINS Y=n45 C=n262 B=n263 AN=n233
XU115 NOR2X1 $PINS Y=n117 B=n286 A=IF_ID_Write
XU116 AND4X1 $PINS Y=n121 D=next_BranchTaken C=n113 B=n111 A=n109
XU117 INVX1 $PINS Y=n257 A=PredictMiss
XU118 INVX1 $PINS Y=n222 A=n125
XU121 OA21XL $PINS Y=n116 B0=n242 A1=IF_Flush A0=PredictMiss
XU122 NOR2XL $PINS Y=N109 B=n122 A=n116
XU123 NOR2XL $PINS Y=N110 B=n116 A=n112
XU124 NOR2XL $PINS Y=N114 B=n116 A=n108
XU125 NOR2XL $PINS Y=N112 B=n116 A=n111
XU126 NOR2XL $PINS Y=N113 B=n116 A=n109
XU127 NOR2BXL $PINS Y=N111 B=n116 AN=n113
XU129 NAND4XL $PINS Y=n256 D=n109 C=n111 B=n110 A=n108
XU130 NOR2XL $PINS Y=n110 B=n113 A=n112
XU131 CLKINVX1 $PINS Y=n242 A=stall
XU132 AOI22XL $PINS Y=n122 B1=read_Instruction[26] B0=n117 A1=n284
+ A0=Instruction[26]
XU133 AOI22X1 $PINS Y=n112 B1=read_Instruction[27] B0=n117 A1=n583 A0=n284
XU134 AND2XL $PINS Y=N175 B=N13 A=read_Instruction[14]
XU135 AND2XL $PINS Y=N174 B=N13 A=read_Instruction[13]
XU136 AND2XL $PINS Y=N173 B=N13 A=read_Instruction[12]
XU137 AND2XL $PINS Y=N164 B=N13 A=read_Instruction[3]
XU138 AND2XL $PINS Y=N165 B=N13 A=read_Instruction[4]
XU139 AND2XL $PINS Y=N166 B=N13 A=read_Instruction[5]
XU140 AND2XL $PINS Y=N167 B=N13 A=read_Instruction[6]
XU141 AND2XL $PINS Y=N168 B=N13 A=read_Instruction[7]
XU142 AND2XL $PINS Y=N169 B=N13 A=read_Instruction[8]
XU143 AND2XL $PINS Y=N170 B=N13 A=read_Instruction[9]
XU144 AND2XL $PINS Y=N171 B=N13 A=read_Instruction[10]
XU145 AND2XL $PINS Y=N172 B=N13 A=read_Instruction[11]
XU146 INVXL $PINS Y=n308 A=read_Instruction[2]
XU147 AND2XL $PINS Y=N162 B=N13 A=read_Instruction[1]
XU148 AND2X2 $PINS Y=N161 B=N13 A=read_Instruction[0]
XU149 INVXL $PINS Y=n307 A=read_Instruction[3]
XU150 INVXL $PINS Y=n305 A=read_Instruction[5]
XU151 AO22XL $PINS Y=n159 B1=n115 B0=Instruction[2] A1=FE_OFN122_n114
+ A0=read_Instruction[2]
XU152 AO22XL $PINS Y=n161 B1=FE_OFN123_n237 B0=Instruction[4] A1=FE_OFN122_n114
+ A0=read_Instruction[4]
XU153 AO22XL $PINS Y=n162 B1=FE_OFN123_n237 B0=Instruction[5] A1=FE_OFN122_n114
+ A0=read_Instruction[5]
XU154 AO22XL $PINS Y=n157 B1=FE_OFN123_n237 B0=Instruction[0] A1=n114
+ A0=read_Instruction[0]
XU155 AO22XL $PINS Y=n158 B1=FE_OFN123_n237 B0=Instruction[1] A1=FE_OFN122_n114
+ A0=read_Instruction[1]
XU156 CLKMX2X2 $PINS Y=n221 S0=n232 B=N28 A=PCadd4[5]
XU157 INVXL $PINS Y=n306 A=read_Instruction[4]
XU158 INVXL $PINS Y=n309 A=read_Instruction[1]
XU159 INVX1 $PINS Y=n280 A=n105
XU160 INVX1 $PINS Y=n281 A=n104
XU161 AO22XL $PINS Y=n181 B1=n114 B0=read_Instruction[24] A1=n115
+ A0=Instruction[24]
XU162 MX2XL $PINS Y=n225 S0=FE_OFN121_n232 B=N23 A=PCadd4[0]
XU163 MX2XL $PINS Y=n226 S0=FE_OFN121_n232 B=N24 A=PCadd4[1]
XU164 XNOR2XL $PINS Y=n119 B=PredictMiss A=n407
XU165 NAND2XL $PINS Y=n118 B=n287 A=PredictMiss
XU166 CLKINVX1 $PINS Y=n239 A=n241
XU168 CLKBUFX3 $PINS Y=n254 A=n246
XU169 CLKBUFX3 $PINS Y=n253 A=n246
XU174 CLKBUFX3 $PINS Y=n251 A=n246
XU177 CLKINVX1 $PINS Y=n233 A=n236
XU179 NAND2BX1 $PINS Y=n259 B=n236 AN=n258
XU180 AOI2BB1X1 $PINS Y=n258 B0=IF_Flush A1N=n257 A0N=n263
XU181 NOR2X1 $PINS Y=n115 B=n117 A=n116
XU182 CLKINVX1 $PINS Y=n262 A=IF_Flush
XU183 CLKINVX1 $PINS Y=n263 A=n256
XU189 AOI2BB2X1 $PINS Y=n265 B1=FE_OFN119_n228 B0=PCBrPredict[29] A1N=n264
+ A0N=n239
XU190 AOI2BB2X1 $PINS Y=n266 B1=FE_OFN118_n230 B0=PCJumpJRorBranch[29] A1N=n396
+ A0N=n236
XU191 CLKINVX1 $PINS Y=PCJumpEarly[27] A=n270
XU193 CLKINVX1 $PINS Y=PCJumpEarly[28] A=n267
XU194 CLKINVX1 $PINS Y=PCJumpEarly[29] A=n264
XU195 CLKINVX1 $PINS Y=n287 A=n120
XU196 CLKINVX1 $PINS Y=n236 A=n285
XU197 NAND2BX1 $PINS Y=n285 B=FE_OFN121_n232 AN=PCWrite
XU198 CLKBUFX3 $PINS Y=n246 A=rst
XU199 CLKINVX1 $PINS Y=n304 A=read_Instruction[6]
XU200 AOI22XL $PINS Y=n89 B1=FE_OFN120_n233 B0=n336 A1=n228 A0=PCBrPredict[8]
XU201 NAND2X1 $PINS Y=n88 B=n278 A=PCJumpJRorBranch[8]
XU202 CLKINVX1 $PINS Y=n303 A=read_Instruction[7]
XU203 AOI22XL $PINS Y=n87 B1=FE_OFN120_n233 B0=n335 A1=n228 A0=PCBrPredict[9]
XU204 NAND2X1 $PINS Y=n86 B=n278 A=PCJumpJRorBranch[9]
XU205 CLKINVX1 $PINS Y=n302 A=read_Instruction[8]
XU206 AOI22XL $PINS Y=n85 B1=FE_OFN120_n233 B0=n334 A1=n228 A0=PCBrPredict[10]
XU207 NAND2X1 $PINS Y=n84 B=n278 A=PCJumpJRorBranch[10]
XU208 CLKINVX1 $PINS Y=n301 A=read_Instruction[9]
XU209 AOI22XL $PINS Y=n83 B1=FE_OFN120_n233 B0=n333 A1=n228 A0=PCBrPredict[11]
XU210 NAND2X1 $PINS Y=n82 B=n278 A=PCJumpJRorBranch[11]
XU211 CLKINVX1 $PINS Y=n300 A=read_Instruction[10]
XU212 AOI22XL $PINS Y=n81 B1=FE_OFN120_n233 B0=n332 A1=n228 A0=PCBrPredict[12]
XU213 NAND2X1 $PINS Y=n80 B=n278 A=PCJumpJRorBranch[12]
XU214 OAI211X1 $PINS Y=n145 C0=n79 B0=n78 A1=n299 A0=FE_OFN117_n239
XU215 CLKINVX1 $PINS Y=n299 A=read_Instruction[11]
XU216 AOI22XL $PINS Y=n79 B1=n285 B0=n385 A1=n228 A0=PCBrPredict[13]
XU217 NAND2X1 $PINS Y=n78 B=n278 A=PCJumpJRorBranch[13]
XU218 CLKINVX1 $PINS Y=n298 A=read_Instruction[12]
XU219 AOI22XL $PINS Y=n77 B1=FE_OFN120_n233 B0=n330 A1=n228 A0=PCBrPredict[14]
XU220 NAND2X1 $PINS Y=n76 B=n278 A=PCJumpJRorBranch[14]
XU221 OAI211X1 $PINS Y=n143 C0=n75 B0=n74 A1=n297 A0=FE_OFN117_n239
XU222 CLKINVX1 $PINS Y=n297 A=read_Instruction[13]
XU223 AOI22XL $PINS Y=n75 B1=n285 B0=n329 A1=n228 A0=PCBrPredict[15]
XU224 NAND2X1 $PINS Y=n74 B=FE_OFN118_n230 A=PCJumpJRorBranch[15]
XU225 CLKINVX1 $PINS Y=n296 A=read_Instruction[14]
XU226 AOI22XL $PINS Y=n73 B1=FE_OFN120_n233 B0=n328 A1=n19 A0=PCBrPredict[16]
XU227 NAND2X1 $PINS Y=n72 B=FE_OFN118_n230 A=PCJumpJRorBranch[16]
XU228 CLKINVX1 $PINS Y=n294 A=read_Instruction[16]
XU229 AOI22XL $PINS Y=n69 B1=FE_OFN120_n233 B0=n326 A1=n19 A0=PCBrPredict[18]
XU230 NAND2X1 $PINS Y=n68 B=FE_OFN118_n230 A=PCJumpJRorBranch[18]
XU231 CLKINVX1 $PINS Y=n293 A=read_Instruction[17]
XU232 AOI22XL $PINS Y=n67 B1=FE_OFN120_n233 B0=n325 A1=n19 A0=PCBrPredict[19]
XU233 NAND2X1 $PINS Y=n66 B=FE_OFN118_n230 A=PCJumpJRorBranch[19]
XU234 CLKINVX1 $PINS Y=n292 A=read_Instruction[18]
XU235 AOI22XL $PINS Y=n65 B1=FE_OFN120_n233 B0=n324 A1=n19 A0=PCBrPredict[20]
XU236 NAND2X1 $PINS Y=n64 B=FE_OFN118_n230 A=PCJumpJRorBranch[20]
XU237 CLKINVX1 $PINS Y=n291 A=read_Instruction[19]
XU238 AOI22XL $PINS Y=n63 B1=FE_OFN120_n233 B0=n323 A1=n19 A0=PCBrPredict[21]
XU239 NAND2X1 $PINS Y=n62 B=FE_OFN118_n230 A=PCJumpJRorBranch[21]
XU240 CLKINVX1 $PINS Y=n290 A=read_Instruction[20]
XU241 AOI22XL $PINS Y=n61 B1=FE_OFN120_n233 B0=n322 A1=FE_OFN119_n228
+ A0=PCBrPredict[22]
XU242 NAND2X1 $PINS Y=n60 B=FE_OFN118_n230 A=PCJumpJRorBranch[22]
XU243 CLKINVX1 $PINS Y=n289 A=read_Instruction[21]
XU244 AOI22XL $PINS Y=n59 B1=n233 B0=n321 A1=FE_OFN119_n228 A0=PCBrPredict[23]
XU245 NAND2X1 $PINS Y=n58 B=FE_OFN118_n230 A=PCJumpJRorBranch[23]
XU246 CLKINVX1 $PINS Y=n288 A=read_Instruction[22]
XU247 AOI22XL $PINS Y=n57 B1=FE_OFN120_n233 B0=n387 A1=FE_OFN119_n228
+ A0=PCBrPredict[24]
XU248 NAND2X1 $PINS Y=n56 B=FE_OFN118_n230 A=PCJumpJRorBranch[24]
XU249 OAI211X1 $PINS Y=n156 C0=n101 B0=n100 A1=n310 A0=FE_OFN117_n239
XU250 AOI22XL $PINS Y=n101 B1=SPCASCAN_N24 B0=FE_OFN120_n233 A1=n228
+ A0=PCBrPredict[2]
XU251 NAND2X1 $PINS Y=n100 B=n278 A=PCJumpJRorBranch[2]
XU252 OAI211X1 $PINS Y=n155 C0=n99 B0=n98 A1=n309 A0=FE_OFN117_n239
XU253 AOI22XL $PINS Y=n99 B1=FE_OFN120_n233 B0=n341 A1=n228 A0=PCBrPredict[3]
XU254 NAND2X1 $PINS Y=n98 B=n278 A=PCJumpJRorBranch[3]
XU255 OAI211X1 $PINS Y=n154 C0=n97 B0=n96 A1=n308 A0=FE_OFN117_n239
XU256 AOI22XL $PINS Y=n97 B1=FE_OFN120_n233 B0=PC[4] A1=n228 A0=PCBrPredict[4]
XU257 NAND2X1 $PINS Y=n96 B=n278 A=PCJumpJRorBranch[4]
XU258 AOI22XL $PINS Y=n91 B1=FE_OFN120_n233 B0=n337 A1=n228 A0=PCBrPredict[7]
XU259 NAND2X1 $PINS Y=n90 B=n278 A=PCJumpJRorBranch[7]
XU260 CLKINVX1 $PINS Y=n295 A=read_Instruction[15]
XU261 AOI22XL $PINS Y=n71 B1=n285 B0=n382 A1=n228 A0=PCBrPredict[17]
XU262 NAND2X1 $PINS Y=n70 B=FE_OFN118_n230 A=PCJumpJRorBranch[17]
XU263 OAI211X1 $PINS Y=n153 C0=n95 B0=n94 A1=FE_OFN117_n239 A0=n307
XU264 AOI22XL $PINS Y=n95 B1=FE_OFN120_n233 B0=n339 A1=n228 A0=PCBrPredict[5]
XU265 NAND2X1 $PINS Y=n94 B=n278 A=PCJumpJRorBranch[5]
XU266 AOI22XL $PINS Y=n93 B1=FE_OFN120_n233 B0=n338 A1=n228 A0=PCBrPredict[6]
XU267 NAND2X1 $PINS Y=n92 B=n278 A=PCJumpJRorBranch[6]
XU268 AOI2BB2X1 $PINS Y=n274 B1=FE_OFN119_n228 B0=PCBrPredict[26] A1N=n273
+ A0N=n239
XU269 AOI2BB2X1 $PINS Y=n275 B1=FE_OFN118_n230 B0=PCJumpJRorBranch[26] A1N=n399
+ A0N=n236
XU270 AOI222XL $PINS Y=n105 C1=FE_OFN119_n228 C0=PCBrPredict[0] B1=n278
+ B0=PCJumpJRorBranch[0] A1=n233 A0=PC[0]
XU271 AOI222XL $PINS Y=n104 C1=FE_OFN119_n228 C0=PCBrPredict[1] B1=n278
+ B0=PCJumpJRorBranch[1] A1=n233 A0=PC[1]
XU272 AOI22X1 $PINS Y=n276 B1=FE_OFN119_n228 B0=PCBrPredict[25]
+ A1=read_Instruction[23] A0=n241
XU274 AOI2BB2X1 $PINS Y=n268 B1=FE_OFN119_n228 B0=PCBrPredict[28] A1N=n267
+ A0N=n239
XU275 AOI2BB2X1 $PINS Y=n269 B1=FE_OFN118_n230 B0=PCJumpJRorBranch[28] A1N=n402
+ A0N=n236
XU276 AOI2BB2X1 $PINS Y=n271 B1=FE_OFN119_n228 B0=PCBrPredict[27] A1N=n270
+ A0N=n239
XU279 AO22X1 $PINS Y=n160 B1=FE_OFN123_n237 B0=Instruction[3] A1=FE_OFN122_n114
+ A0=read_Instruction[3]
XU280 AO22X1 $PINS Y=n171 B1=FE_OFN123_n237 B0=Instruction[14]
+ A1=FE_OFN122_n114 A0=read_Instruction[14]
XU281 AO22X1 $PINS Y=n170 B1=FE_OFN123_n237 B0=Instruction[13]
+ A1=FE_OFN122_n114 A0=read_Instruction[13]
XU282 AO22X1 $PINS Y=n166 B1=FE_OFN123_n237 B0=Instruction[9] A1=FE_OFN122_n114
+ A0=read_Instruction[9]
XU283 AO22X1 $PINS Y=n169 B1=FE_OFN123_n237 B0=Instruction[12]
+ A1=FE_OFN122_n114 A0=read_Instruction[12]
XU284 AO22X1 $PINS Y=n165 B1=n115 B0=Instruction[8] A1=n114
+ A0=read_Instruction[8]
XU285 AO22X1 $PINS Y=n168 B1=FE_OFN123_n237 B0=Instruction[11]
+ A1=FE_OFN122_n114 A0=read_Instruction[11]
XU286 AO22X1 $PINS Y=n163 B1=n115 B0=Instruction[6] A1=FE_OFN122_n114
+ A0=read_Instruction[6]
XU287 AO22X1 $PINS Y=n164 B1=n115 B0=Instruction[7] A1=n114
+ A0=read_Instruction[7]
XU288 AO22X1 $PINS Y=n172 B1=FE_OFN123_n237 B0=Instruction[15]
+ A1=FE_OFN122_n114 A0=read_Instruction[15]
XU289 AO22X1 $PINS Y=n167 B1=FE_OFN123_n237 B0=Instruction[10]
+ A1=FE_OFN122_n114 A0=read_Instruction[10]
XU290 AO22X1 $PINS Y=n173 B1=FE_OFN123_n237 B0=Instruction[16]
+ A1=FE_OFN122_n114 A0=read_Instruction[16]
XU291 AO22X1 $PINS Y=n174 B1=FE_OFN123_n237 B0=Instruction[17]
+ A1=FE_OFN122_n114 A0=read_Instruction[17]
XU292 AO22X1 $PINS Y=n175 B1=FE_OFN123_n237 B0=Instruction[18]
+ A1=FE_OFN122_n114 A0=read_Instruction[18]
XU293 AO22X1 $PINS Y=n176 B1=FE_OFN123_n237 B0=Instruction[19]
+ A1=FE_OFN122_n114 A0=read_Instruction[19]
XU294 AO22X1 $PINS Y=n177 B1=FE_OFN123_n237 B0=Instruction[20]
+ A1=FE_OFN122_n114 A0=read_Instruction[20]
XU295 AO22X1 $PINS Y=n178 B1=FE_OFN123_n237 B0=Instruction[21]
+ A1=FE_OFN122_n114 A0=read_Instruction[21]
XU296 AO22X1 $PINS Y=n179 B1=FE_OFN123_n237 B0=Instruction[22] A1=n114
+ A0=read_Instruction[22]
XU297 AO22X1 $PINS Y=n180 B1=FE_OFN123_n237 B0=Instruction[23]
+ A1=FE_OFN122_n114 A0=read_Instruction[23]
XU298 AOI22X1 $PINS Y=n108 B1=read_Instruction[31] B0=n117 A1=n284
+ A0=Instruction[31]
XU299 AOI22X1 $PINS Y=n109 B1=read_Instruction[30] B0=n117 A1=n284
+ A0=Instruction[30]
XU300 AOI22X1 $PINS Y=n111 B1=read_Instruction[29] B0=n117 A1=n284
+ A0=Instruction[29]
XU301 AO22X1 $PINS Y=n113 B1=read_Instruction[28] B0=n117 A1=Instruction[28]
+ A0=n284
XU302 CLKINVX1 $PINS Y=n310 A=read_Instruction[0]
XU303 AND2X2 $PINS Y=N163 B=N13 A=read_Instruction[2]
XU304 NOR3X1 $PINS Y=n124 C=Instruction[30] B=Instruction[31] A=Instruction[29]
XU305 OAI22XL $PINS Y=N73 B1=n120 B0=n119 A1=n8 A0=n287
XU306 OAI2BB2XL $PINS Y=N74 B1=n8 B0=n118 A1N=n407 A0N=n118
Xadd_71 InstructionFetch_DW01_add_0 $PINS A[31]=n313 A[30]=n314 A[29]=n315
+ A[28]=n316 A[27]=n317 A[26]=n318 A[25]=n319 A[24]=n387 A[23]=n321 A[22]=n322
+ A[21]=n323 A[20]=n324 A[19]=n325 A[18]=n326 A[17]=n382 A[16]=n328 A[15]=n329
+ A[14]=n330 A[13]=n385 A[12]=n332 A[11]=n333 A[10]=n334 A[9]=n335 A[8]=n336
+ A[7]=n337 A[6]=n338 A[5]=n339 A[4]=n340 A[3]=n341 A[2]=n342 A[1]=n13 A[0]=n12
+ B[31]=VSS B[30]=VSS B[29]=VSS B[28]=VSS B[27]=VSS B[26]=VSS B[25]=VSS B[24]=VSS
+ B[23]=VSS B[22]=VSS B[21]=VSS B[20]=VSS B[19]=VSS B[18]=VSS B[17]=VSS B[16]=VSS
+ B[15]=VSS B[14]=VSS B[13]=VSS B[12]=VSS B[11]=VSS B[10]=VSS B[9]=VSS B[8]=VSS
+ B[7]=VSS B[6]=VSS B[5]=VSS B[4]=VSS B[3]=VSS B[2]=VDD B[1]=VSS B[0]=VSS CI=VSS
+ SUM[31]=N54 SUM[30]=N53 SUM[29]=N52 SUM[28]=N51 SUM[27]=N50 SUM[26]=N49
+ SUM[25]=N48 SUM[24]=N47 SUM[23]=N46 SUM[22]=N45 SUM[21]=N44 SUM[20]=N43
+ SUM[19]=N42 SUM[18]=N41 SUM[17]=N40 SUM[16]=N39 SUM[15]=N38 SUM[14]=N37
+ SUM[13]=N36 SUM[12]=N35 SUM[11]=N34 SUM[10]=N33 SUM[9]=N32 SUM[8]=N31
+ SUM[7]=N30 SUM[6]=N29 SUM[5]=N28 SUM[4]=N27 SUM[3]=N26 SUM[2]=N25 SUM[1]=N24
+ SUM[0]=N23
Xadd_57_aco InstructionFetch_DW01_add_1 $PINS A[31]=PCJumpEarly[29]
+ A[30]=PCJumpEarly[28] A[29]=PCJumpEarly[27] A[28]=n384 A[27]=n16 A[26]=n18
+ A[25]=n17 A[24]=n6 A[23]=n5 A[22]=n7 A[21]=n4 A[20]=n2 A[19]=n9 A[18]=n11
+ A[17]=n10 A[16]=n30 A[15]=n27 A[14]=n28 A[13]=n29 A[12]=n26 A[11]=n23 A[10]=n24
+ A[9]=n22 A[8]=n25 A[7]=n21 A[6]=n15 A[5]=n221 A[4]=n14 A[3]=n3 A[2]=n220
+ A[1]=n226 A[0]=n225 B[31]=n224 B[30]=n224 B[29]=n224 B[28]=n224 B[27]=n224
+ B[26]=n224 B[25]=n224 B[24]=n224 B[23]=n224 B[22]=n224 B[21]=n224 B[20]=n224
+ B[19]=n224 B[18]=n224 B[17]=n224 B[16]=N175 B[15]=N174 B[14]=N173 B[13]=N172
+ B[12]=N171 B[11]=N170 B[10]=N169 B[9]=N168 B[8]=N167 B[7]=N166 B[6]=N165
+ B[5]=N164 B[4]=N163 B[3]=N162 B[2]=N161 B[1]=VSS B[0]=VSS CI=VSS
+ SUM[31]=PCBrPredict[31] SUM[30]=PCBrPredict[30] SUM[29]=PCBrPredict[29]
+ SUM[28]=PCBrPredict[28] SUM[27]=PCBrPredict[27] SUM[26]=PCBrPredict[26]
+ SUM[25]=PCBrPredict[25] SUM[24]=PCBrPredict[24] SUM[23]=PCBrPredict[23]
+ SUM[22]=PCBrPredict[22] SUM[21]=PCBrPredict[21] SUM[20]=PCBrPredict[20]
+ SUM[19]=PCBrPredict[19] SUM[18]=PCBrPredict[18] SUM[17]=PCBrPredict[17]
+ SUM[16]=PCBrPredict[16] SUM[15]=PCBrPredict[15] SUM[14]=PCBrPredict[14]
+ SUM[13]=PCBrPredict[13] SUM[12]=PCBrPredict[12] SUM[11]=PCBrPredict[11]
+ SUM[10]=PCBrPredict[10] SUM[9]=PCBrPredict[9] SUM[8]=PCBrPredict[8]
+ SUM[7]=PCBrPredict[7] SUM[6]=PCBrPredict[6] SUM[5]=PCBrPredict[5]
+ SUM[4]=PCBrPredict[4] SUM[3]=PCBrPredict[3] SUM[2]=PCBrPredict[2]
+ SUM[1]=PCBrPredict[1] SUM[0]=PCBrPredict[0]
Xnext_state_reg[0] TLATX1 $PINS Q=next_state[0] G=n232 D=N73
XPC_reg[31] SDFFRX2 $PINS SI=SPCASCAN_N5 SE=FE_OFN108_test_se_i RN=n251 QN=n35
+ Q=n313 D=n282 CK=clk_i__L3_N27
XPC_reg[9] SDFFRX2 $PINS SI=SPCASCAN_N3 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n198 Q=n335 D=n149 CK=clk_i__L3_N25
XPC_reg[3] SDFFRX2 $PINS SI=n340 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249 QN=n216
+ Q=n341 D=n155 CK=clk_i__L3_N7
XPC_reg[2] SDFFRX2 $PINS SI=SPCASCAN_N25 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n214 Q=n342 D=n156 CK=clk_i__L3_N7
Xstate_reg[0] SDFFSXL $PINS SN=n251 SI=n203 SE=FE_OFN107_test_se_i QN=n8 Q=n376
+ D=next_state[0] CK=clk_i__L3_N25
XInstruction_reg[1] SDFFRXL $PINS SI=n373 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n375 Q=Instruction[1] D=n158 CK=clk
XInstruction_reg[0] SDFFRXL $PINS SI=n47 SE=FE_OFN23_test_se_i RN=n254 QN=n374
+ Q=Instruction[0] D=n157 CK=clk
XInstruction_reg[10] SDFFRXL $PINS SI=n367 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n373 Q=Instruction[10] D=n167 CK=clk
XInstruction_reg[5] SDFFRXL $PINS SI=n369 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n372 Q=n632 D=n162 CK=clk
XInstruction_reg[7] SDFFRXL $PINS SI=n364 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n371 Q=n630 D=n164 CK=clk
XInstruction_reg[2] SDFFRXL $PINS SI=n372 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n370 Q=n635 D=n159 CK=clk
XInstruction_reg[6] SDFFRXL $PINS SI=n368 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n369 Q=n631 D=n163 CK=clk
XInstruction_reg[4] SDFFRXL $PINS SI=n348 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n368 Q=n633 D=n161 CK=clk
XInstruction_reg[11] SDFFRXL $PINS SI=n360 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n367 Q=n627 D=n168 CK=clk
XInstruction_reg[8] SDFFRXL $PINS SI=n371 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n366 Q=n629 D=n165 CK=clk
XInstruction_reg[12] SDFFRXL $PINS SI=n349 SE=FE_OFN103_test_se_i
+ RN=FE_OFN143_n253 QN=n365 Q=n626 D=n169 CK=clk
XInstruction_reg[9] SDFFRXL $PINS SI=n370 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n364 Q=n628 D=n166 CK=clk
Xstate_reg[1] SDFFSXL $PINS SN=n251 SI=n376 SE=FE_OFN105_test_se_i QN=test_so
+ Q=state[1] D=next_state[1] CK=clk
XPCadd4_reg[1] SDFFRXL $PINS SI=n103 SE=test_se RN=FE_OFN142_n254 QN=n362
+ Q=n615 D=n226 CK=clk_i__L3_N26
XPCadd4_reg[0] SDFFRXL $PINS SI=n362 SE=test_se RN=n251 QN=n361 Q=n616 D=n225
+ CK=clk_i__L3_N25
XInstruction_reg[23] SDFFRXL $PINS SI=n365 SE=FE_OFN103_test_se_i
+ RN=FE_OFN143_n253 QN=n360 Q=Instruction[23] D=n180 CK=clk
XInstruction_reg[22] SDFFRXL $PINS SI=n42 SE=FE_OFN23_test_se_i
+ RN=FE_OFN143_n253 QN=SPCASCAN_N14 Q=Instruction[22] D=n179 CK=clk
XInstruction_reg[21] SDFFRXL $PINS SI=n355 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=SPCASCAN_N18 Q=Instruction[21] D=n178 CK=clk
XInstruction_reg[20] SDFFRXL $PINS SI=test_si SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n357 Q=Instruction[20] D=n177 CK=clk_i__L3_N9
XInstruction_reg[19] SDFFRXL $PINS SI=n357 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=SPCASCAN_N20 Q=Instruction[19] D=n176 CK=clk_i__L3_N9
XInstruction_reg[18] SDFFRXL $PINS SI=n354 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n355 Q=Instruction[18] D=n175 CK=clk
XInstruction_reg[17] SDFFRXL $PINS SI=SPCASCAN_N20 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n354 Q=Instruction[17] D=n174 CK=clk
XInstruction_reg[16] SDFFRXL $PINS SI=n49 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n353 Q=Instruction[16] D=n173 CK=clk
XInstruction_reg[25] SDFFRXL $PINS SI=n351 SE=FE_OFN23_test_se_i RN=n254
+ QN=n352 Q=Instruction[25] D=n182 CK=clk
XInstruction_reg[24] SDFFRXL $PINS SI=n366 SE=FE_OFN23_test_se_i RN=n254
+ QN=n351 Q=Instruction[24] D=n181 CK=clk
XInstruction_reg[13] SDFFRXL $PINS SI=n353 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n350 Q=n625 D=n170 CK=clk
XInstruction_reg[14] SDFFRXL $PINS SI=n350 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n349 Q=n624 D=n171 CK=clk
XInstruction_reg[3] SDFFRXL $PINS SI=n375 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n348 Q=n634 D=n160 CK=clk
XPCadd4_reg[27] SDFFRXL $PINS SI=SPCASCAN_N4 SE=FE_OFN107_test_se_i
+ RN=FE_OFN142_n254 QN=n347 Q=n589 D=n16 CK=clk_i__L3_N25
XPCadd4_reg[26] SDFFRXL $PINS SI=n361 SE=FE_OFN107_test_se_i RN=FE_OFN142_n254
+ QN=n346 Q=n590 D=n18 CK=clk_i__L3_N25
XPCadd4_reg[25] SDFFRXL $PINS SI=n346 SE=FE_OFN107_test_se_i RN=FE_OFN142_n254
+ QN=n345 Q=n591 D=n17 CK=clk_i__L3_N25
XPCadd4_reg[24] SDFFRXL $PINS SI=n345 SE=FE_OFN105_test_se_i RN=n253 QN=n344
+ Q=n592 D=n6 CK=clk_i__L3_N25
XPCadd4_reg[23] SDFFRXL $PINS SI=n312 SE=FE_OFN107_test_se_i RN=n253 QN=n343
+ Q=n593 D=n5 CK=clk_i__L3_N25
XPCadd4_reg[22] SDFFRXL $PINS SI=n311 SE=FE_OFN109_test_se_i RN=n253 QN=n312
+ Q=n594 D=n7 CK=clk_i__L3_N25
XPCadd4_reg[21] SDFFRXL $PINS SI=n217 SE=FE_OFN109_test_se_i RN=n253 QN=n311
+ Q=n595 D=n4 CK=clk_i__L3_N9
XPCadd4_reg[20] SDFFRXL $PINS SI=n215 SE=FE_OFN109_test_se_i RN=n253 QN=n217
+ Q=n596 D=n2 CK=clk_i__L3_N9
XPCadd4_reg[19] SDFFRXL $PINS SI=n213 SE=FE_OFN109_test_se_i RN=n253 QN=n215
+ Q=n597 D=n9 CK=clk_i__L3_N25
XPCadd4_reg[18] SDFFRXL $PINS SI=n211 SE=FE_OFN105_test_se_i RN=n253 QN=n213
+ Q=n598 D=n11 CK=clk_i__L3_N25
XPCadd4_reg[17] SDFFRXL $PINS SI=n209 SE=FE_OFN105_test_se_i RN=n253 QN=n211
+ Q=n599 D=n10 CK=clk
XPCadd4_reg[16] SDFFRXL $PINS SI=n207 SE=FE_OFN105_test_se_i RN=n253 QN=n209
+ Q=n600 D=n30 CK=clk
XPCadd4_reg[15] SDFFRXL $PINS SI=n205 SE=FE_OFN105_test_se_i RN=n253 QN=n207
+ Q=n601 D=n27 CK=clk
XPCadd4_reg[14] SDFFRXL $PINS SI=test_so SE=FE_OFN107_test_se_i RN=n253 QN=n205
+ Q=n602 D=n28 CK=clk
XPCadd4_reg[13] SDFFRXL $PINS SI=n201 SE=FE_OFN107_test_se_i RN=n253 QN=n203
+ Q=n603 D=n29 CK=clk_i__L3_N25
XPCadd4_reg[12] SDFFRXL $PINS SI=n199 SE=FE_OFN107_test_se_i RN=n254 QN=n201
+ Q=n604 D=n26 CK=clk_i__L3_N25
XPCadd4_reg[11] SDFFRXL $PINS SI=n197 SE=FE_OFN23_test_se_i RN=n254 QN=n199
+ Q=n605 D=n23 CK=clk_i__L3_N25
XPCadd4_reg[10] SDFFRXL $PINS SI=n195 SE=FE_OFN23_test_se_i RN=n254 QN=n197
+ Q=n606 D=n24 CK=clk_i__L3_N25
XPCadd4_reg[9] SDFFRXL $PINS SI=n191 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n195 Q=n607 D=n22 CK=clk_i__L3_N25
XPCadd4_reg[8] SDFFRXL $PINS SI=n189 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n193 Q=n608 D=n25 CK=clk_i__L3_N25
XPCadd4_reg[7] SDFFRXL $PINS SI=n193 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n191 Q=n609 D=n21 CK=clk_i__L3_N25
XPCadd4_reg[6] SDFFRXL $PINS SI=n187 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n189 Q=n610 D=n15 CK=clk_i__L3_N25
XPCadd4_reg[5] SDFFRXL $PINS SI=n185 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n187 Q=n611 D=n221 CK=clk_i__L3_N7
XPCadd4_reg[4] SDFFRXL $PINS SI=n183 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n185 Q=n612 D=n14 CK=clk_i__L3_N7
XPCadd4_reg[3] SDFFRXL $PINS SI=n107 SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n183 Q=n613 D=n3 CK=clk_i__L3_N7
XPCadd4_reg[2] SDFFRXL $PINS SI=PC[10] SE=FE_OFN8_test_se_i RN=FE_OFN142_n254
+ QN=n107 Q=n614 D=n220 CK=clk_i__L3_N7
XPCadd4_reg[28] SDFFRXL $PINS SI=n53 SE=test_se RN=FE_OFN142_n254 QN=n103
+ Q=n588 D=n384 CK=clk_i__L3_N26
XPCadd4_reg[29] SDFFRXL $PINS SI=n51 SE=FE_OFN107_test_se_i RN=FE_OFN142_n254
+ QN=n55 Q=n587 D=PCJumpEarly[27] CK=clk_i__L3_N26
XPCadd4_reg[30] SDFFRXL $PINS SI=n55 SE=test_se RN=FE_OFN142_n254 QN=n53 Q=n586
+ D=PCJumpEarly[28] CK=clk_i__L3_N26
XPCadd4_reg[31] SDFFRXL $PINS SI=n347 SE=FE_OFN107_test_se_i RN=FE_OFN142_n254
+ QN=n51 Q=n585 D=PCJumpEarly[29] CK=clk_i__L3_N27
XInstruction_reg[15] SDFFRXL $PINS SI=SPCASCAN_N15 SE=FE_OFN104_test_se_i
+ RN=FE_OFN143_n253 QN=n49 Q=n623 D=n172 CK=clk
XInstruction_reg[29] SDFFRXL $PINS SI=n36 SE=FE_OFN23_test_se_i
+ RN=FE_OFN145_n251 QN=n47 Q=Instruction[29] D=N112 CK=clk
XInstruction_reg[30] SDFFRXL $PINS SI=n38 SE=FE_OFN23_test_se_i
+ RN=FE_OFN145_n251 QN=n44 Q=Instruction[30] D=N113 CK=clk
XPC_reg[30] SDFFRXL $PINS SI=n13 SE=FE_OFN108_test_se_i RN=n251 QN=n48 Q=n314
+ D=n283 CK=clk_i__L3_N27
XPC_reg[0] SDFFRXL $PINS SI=SPCASCAN_N13 SE=test_se RN=FE_OFN144_n249 QN=n31
+ Q=n12 D=n280 CK=clk_i__L3_N25
XPC_reg[1] SDFFRXL $PINS SI=SPCASCAN_N23 SE=test_se RN=FE_OFN144_n249 QN=n32
+ Q=n13 D=n281 CK=clk_i__L3_N26
XBranchTaken_reg SDFFRXL $PINS SI=n374 SE=FE_OFN23_test_se_i RN=n254 QN=n42
+ Q=BranchTaken D=next_BranchTaken CK=clk
XInstruction_reg[27] SDFFRXL $PINS SI=n34 SE=FE_OFN103_test_se_i
+ RN=FE_OFN145_n251 QN=n40 Q=n621 D=N110 CK=clk
XInstruction_reg[26] SDFFRXL $PINS SI=n352 SE=FE_OFN23_test_se_i RN=n254 QN=n38
+ Q=n622 D=N109 CK=clk
XInstruction_reg[28] SDFFRXL $PINS SI=n40 SE=FE_OFN23_test_se_i
+ RN=FE_OFN145_n251 QN=n36 Q=Instruction[28] D=N111 CK=clk
XInstruction_reg[31] SDFFRXL $PINS SI=n44 SE=FE_OFN23_test_se_i
+ RN=FE_OFN145_n251 QN=n34 Q=Instruction[31] D=N114 CK=clk
XPC_reg[27] SDFFRXL $PINS SI=PC[28] SE=FE_OFN108_test_se_i RN=FE_OFN142_n254
+ QN=n39 Q=n317 D=n131 CK=clk_i__L3_N27
XPC_reg[28] SDFFRXL $PINS SI=PC[29] SE=FE_OFN107_test_se_i RN=FE_OFN142_n254
+ QN=n43 Q=n316 D=n130 CK=clk_i__L3_N27
XPC_reg[26] SDFFRXL $PINS SI=PC[27] SE=FE_OFN109_test_se_i RN=FE_OFN142_n254
+ QN=n41 Q=n318 D=n132 CK=clk_i__L3_N25
XPC_reg[29] SDFFRXL $PINS SI=n12 SE=FE_OFN107_test_se_i RN=FE_OFN142_n254
+ QN=n46 Q=n315 D=n129 CK=clk_i__L3_N27
XPC_reg[25] SDFFRXL $PINS SI=SPCASCAN_N7 SE=FE_OFN107_test_se_i RN=n251 QN=n37
+ Q=n319 D=n133 CK=clk_i__L3_N25
XPC_reg[23] SDFFRXL $PINS SI=SPCASCAN_N11 SE=FE_OFN107_test_se_i RN=n251
+ QN=n196 Q=n321 D=n135 CK=clk_i__L3_N25
XPC_reg[22] SDFFRXL $PINS SI=SPCASCAN_N9 SE=FE_OFN107_test_se_i RN=n251 QN=n50
+ Q=n322 D=n136 CK=clk_i__L3_N25
XPC_reg[21] SDFFRXL $PINS SI=PC[20] SE=FE_OFN109_test_se_i RN=n251 QN=n192
+ Q=n323 D=n137 CK=clk_i__L3_N25
XPC_reg[20] SDFFRXL $PINS SI=PC[19] SE=FE_OFN107_test_se_i RN=n251 QN=n54
+ Q=n324 D=n138 CK=clk_i__L3_N25
XPC_reg[19] SDFFRXL $PINS SI=n343 SE=FE_OFN109_test_se_i RN=FE_OFN144_n249
+ QN=n106 Q=n325 D=n139 CK=clk_i__L3_N25
XPC_reg[18] SDFFRXL $PINS SI=n344 SE=FE_OFN105_test_se_i RN=FE_OFN144_n249
+ QN=n190 Q=n326 D=n140 CK=clk_i__L3_N25
XPC_reg[16] SDFFRXL $PINS SI=PC[15] SE=FE_OFN105_test_se_i RN=FE_OFN144_n249
+ QN=n126 Q=n328 D=n142 CK=clk_i__L3_N25
XPC_reg[15] SDFFRXL $PINS SI=PC[14] SE=FE_OFN107_test_se_i RN=FE_OFN144_n249
+ QN=n208 Q=n329 D=n143 CK=clk_i__L3_N25
XPC_reg[14] SDFFRXL $PINS SI=PC[13] SE=FE_OFN105_test_se_i RN=FE_OFN144_n249
+ QN=n186 Q=n330 D=n144 CK=clk_i__L3_N25
XPC_reg[12] SDFFRXL $PINS SI=PC[11] SE=FE_OFN107_test_se_i RN=FE_OFN144_n249
+ QN=n188 Q=n332 D=n146 CK=clk_i__L3_N25
XPC_reg[11] SDFFRXL $PINS SI=test_si_i SE=FE_OFN107_test_se_i RN=FE_OFN144_n249
+ QN=n184 Q=n333 D=n147 CK=clk_i__L3_N25
XPC_reg[10] SDFFRXL $PINS SI=SPCASCAN_N1 SE=FE_OFN23_test_se_i
+ RN=FE_OFN144_n249 QN=n102 Q=n334 D=n148 CK=clk_i__L3_N25
XPC_reg[8] SDFFRXL $PINS SI=SPCASCAN_N2 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n204 Q=n336 D=n150 CK=clk_i__L3_N25
XPC_reg[7] SDFFRXL $PINS SI=SPCASCAN_N27 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n202 Q=n337 D=n151 CK=clk_i__L3_N7
XPC_reg[6] SDFFRXL $PINS SI=SPCASCAN_N28 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n200 Q=n338 D=n152 CK=clk_i__L3_N25
XPC_reg[5] SDFFRXL $PINS SI=SPCASCAN_N29 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n210 Q=n339 D=n153 CK=clk_i__L3_N26
XPC_reg[4] SDFFRXL $PINS SI=SPCASCAN_N26 SE=FE_OFN8_test_se_i RN=FE_OFN144_n249
+ QN=n212 Q=n340 D=n154 CK=clk_i__L3_N7
XPC_reg[24] SDFFRX4 $PINS SI=SPCASCAN_N0 SE=FE_OFN105_test_se_i RN=n251 Q=n387
+ D=n134 CK=clk_i__L3_N25
XPC_reg[13] SDFFRHQX8 $PINS SI=PC[12] SE=FE_OFN107_test_se_i RN=FE_OFN144_n249
+ Q=n385 D=n145 CK=clk_i__L3_N25
XPC_reg[17] SDFFRHQX8 $PINS SI=PC[16] SE=FE_OFN105_test_se_i RN=FE_OFN144_n249
+ Q=n382 D=n141 CK=clk_i__L3_N25
XU1 CLKBUFX3 $PINS Y=n377 A=n48
XU6 CLKBUFX2 $PINS Y=n379 A=n39
XU66 CLKINVX3 $PINS Y=n383 A=n382
XU105 CLKMX2X2 $PINS Y=n384 S0=n286 B=n496 A=N51
XU176 INVX1 $PINS Y=n273 A=n384
XU192 INVX2 $PINS Y=n386 A=n385
XU273 AOI22X1 $PINS Y=n272 B1=n389 B0=FE_OFN120_n233 A1=FE_OFN118_n230
+ A0=PCJumpJRorBranch[27]
XU277 INVX1 $PINS Y=n389 A=n379
XU307 OAI2BB2XL $PINS Y=n260 B1=n236 B0=n35 A1N=FE_OFN118_n230
+ A0N=PCJumpJRorBranch[31]
XU308 OAI2BB2XL $PINS Y=n261 B1=n236 B0=n377 A1N=FE_OFN118_n230
+ A0N=PCJumpJRorBranch[30]
XU309 OR2X1 $PINS Y=n391 B=n116 A=n115
XU310 CLKINVX1 $PINS Y=n114 A=n391
XU311 INVX1 $PINS Y=n392 A=n218
XU312 OR2X1 $PINS Y=n133 B=n219 A=n393
XU313 NAND2X1 $PINS Y=n393 B=n276 A=n392
XU314 CLKINVX3 $PINS Y=n394 A=n387
XU315 CLKINVX1 $PINS Y=n395 A=n46
XU316 CLKINVX3 $PINS Y=n396 A=n395
XU318 CLKINVX1 $PINS Y=n398 A=n41
XU319 CLKINVX3 $PINS Y=n399 A=n398
XU321 CLKINVX1 $PINS Y=n401 A=n43
XU322 CLKINVX3 $PINS Y=n402 A=n401
XU324 CLKINVX3 $PINS Y=n404 A=n39
XU325 CLKINVX1 $PINS Y=n405 A=n404
XU326 INVXL $PINS Y=n406 A=state[1]
XU327 INVXL $PINS Y=n407 A=n406
XU330 INVXL $PINS Y=n410 A=n616
XU331 INVXL $PINS Y=PCadd4[0] A=n410
XU333 INVXL $PINS Y=n413 A=n615
XU334 INVXL $PINS Y=PCadd4[1] A=n413
XU336 INVXL $PINS Y=n416 A=n635
XU337 INVXL $PINS Y=Instruction[2] A=n416
XU339 INVXL $PINS Y=n419 A=n633
XU340 INVXL $PINS Y=Instruction[4] A=n419
XU342 INVXL $PINS Y=n422 A=n631
XU343 INVXL $PINS Y=Instruction[6] A=n422
XU345 INVXL $PINS Y=n425 A=n629
XU346 INVXL $PINS Y=Instruction[8] A=n425
XU348 INVXL $PINS Y=n428 A=n628
XU349 INVXL $PINS Y=Instruction[9] A=n428
XU354 CLKBUFX2 $PINS Y=PCadd4[28] A=n496
XU355 INVXL $PINS Y=n435 A=n632
XU356 INVXL $PINS Y=Instruction[5] A=n435
XU359 INVXL $PINS Y=n439 A=n630
XU360 INVXL $PINS Y=Instruction[7] A=n439
XU362 INVXL $PINS Y=n442 A=n623
XU363 INVXL $PINS Y=Instruction[15] A=n442
XU367 CLKBUFX2 $PINS Y=PCadd4[22] A=n508
XU368 CLKBUFX2 $PINS Y=PCadd4[26] A=n511
XU369 INVX12 $PINS Y=PC[2] A=n214
XU371 INVXL $PINS Y=n451 A=n627
XU372 INVXL $PINS Y=Instruction[11] A=n451
XU374 INVXL $PINS Y=n454 A=n626
XU375 INVXL $PINS Y=Instruction[12] A=n454
XU377 INVXL $PINS Y=n457 A=n624
XU378 INVXL $PINS Y=Instruction[14] A=n457
XU380 INVXL $PINS Y=n460 A=n625
XU381 INVXL $PINS Y=Instruction[13] A=n460
XU383 CLKBUFX2 $PINS Y=PCadd4[21] A=n514
XU387 CLKBUFX2 $PINS Y=PCadd4[13] A=n529
XU388 CLKBUFX2 $PINS Y=PCadd4[17] A=n532
XU391 CLKBUFX2 $PINS Y=PCadd4[12] A=n547
XU392 CLKBUFX2 $PINS Y=PCadd4[14] A=n550
XU393 CLKBUFX2 $PINS Y=PCadd4[18] A=n553
XU394 CLKBUFX2 $PINS Y=PCadd4[23] A=n538
XU395 CLKBUFX2 $PINS Y=PCadd4[24] A=n541
XU396 CLKBUFX2 $PINS Y=PCadd4[16] A=n556
XU397 CLKBUFX2 $PINS Y=PCadd4[19] A=n559
XU398 CLKBUFX2 $PINS Y=PCadd4[25] A=n562
XU399 CLKBUFX2 $PINS Y=PCadd4[10] A=n565
XU400 CLKBUFX2 $PINS Y=PCadd4[20] A=n568
XU402 CLKBUFX2 $PINS Y=PCadd4[15] A=n574
XU403 INVXL $PINS Y=n483 A=n587
XU404 INVXL $PINS Y=PCadd4[29] A=n483
XU406 INVXL $PINS Y=n486 A=n634
XU407 INVXL $PINS Y=Instruction[3] A=n486
XU409 INVXL $PINS Y=n489 A=n613
XU410 INVXL $PINS Y=PCadd4[3] A=n489
XU412 INVXL $PINS Y=n492 A=n585
XU413 INVXL $PINS Y=PCadd4[31] A=n492
XU415 INVXL $PINS Y=n495 A=n588
XU416 INVXL $PINS Y=n496 A=n495
XU418 INVXL $PINS Y=n498 A=n589
XU419 INVXL $PINS Y=PCadd4[27] A=n498
XU421 INVXL $PINS Y=n501 A=n586
XU422 INVXL $PINS Y=PCadd4[30] A=n501
XU424 INVXL $PINS Y=n504 A=n608
XU425 CLKINVX1 $PINS Y=PCadd4[8] A=n504
XU427 INVXL $PINS Y=n507 A=n594
XU428 INVXL $PINS Y=n508 A=n507
XU430 INVXL $PINS Y=n510 A=n590
XU431 INVXL $PINS Y=n511 A=n510
XU433 INVXL $PINS Y=n513 A=n595
XU434 INVXL $PINS Y=n514 A=n513
XU436 INVXL $PINS Y=n516 A=n614
XU437 INVXL $PINS Y=PCadd4[2] A=n516
XU439 INVXL $PINS Y=n519 A=n611
XU440 INVXL $PINS Y=PCadd4[5] A=n519
XU442 INVXL $PINS Y=n522 A=n607
XU443 INVXL $PINS Y=PCadd4[9] A=n522
XU445 INVXL $PINS Y=n525 A=n605
XU446 INVXL $PINS Y=PCadd4[11] A=n525
XU448 INVXL $PINS Y=n528 A=n603
XU449 INVXL $PINS Y=n529 A=n528
XU451 INVXL $PINS Y=n531 A=n599
XU452 INVXL $PINS Y=n532 A=n531
XU454 INVXL $PINS Y=n534 A=n612
XU455 INVXL $PINS Y=PCadd4[4] A=n534
XU457 INVXL $PINS Y=n537 A=n593
XU458 INVXL $PINS Y=n538 A=n537
XU460 INVXL $PINS Y=n540 A=n592
XU461 INVXL $PINS Y=n541 A=n540
XU463 INVXL $PINS Y=n543 A=n610
XU464 INVXL $PINS Y=PCadd4[6] A=n543
XU466 INVXL $PINS Y=n546 A=n604
XU467 INVXL $PINS Y=n547 A=n546
XU469 INVXL $PINS Y=n549 A=n602
XU470 INVXL $PINS Y=n550 A=n549
XU472 INVXL $PINS Y=n552 A=n598
XU473 INVXL $PINS Y=n553 A=n552
XU475 INVXL $PINS Y=n555 A=n600
XU476 INVXL $PINS Y=n556 A=n555
XU478 INVXL $PINS Y=n558 A=n597
XU479 INVXL $PINS Y=n559 A=n558
XU481 INVXL $PINS Y=n561 A=n591
XU482 INVXL $PINS Y=n562 A=n561
XU484 INVXL $PINS Y=n564 A=n606
XU485 INVXL $PINS Y=n565 A=n564
XU487 INVXL $PINS Y=n567 A=n596
XU488 INVXL $PINS Y=n568 A=n567
XU490 INVXL $PINS Y=n570 A=n609
XU491 INVXL $PINS Y=PCadd4[7] A=n570
XU493 INVXL $PINS Y=n573 A=n601
XU494 INVXL $PINS Y=n574 A=n573
XU500 CLKBUFX2 $PINS Y=Instruction[26] A=n622
XU501 CLKBUFX2 $PINS Y=Instruction[27] A=n583
XU502 INVXL $PINS Y=n582 A=n621
XU503 INVXL $PINS Y=n583 A=n582
.ENDS

.SUBCKT MIPS_Pipeline clk rst ICACHE_addr[31] ICACHE_addr[30] ICACHE_addr[29]
+ ICACHE_addr[28] ICACHE_addr[27] ICACHE_addr[26] ICACHE_addr[25]
+ ICACHE_addr[24] ICACHE_addr[23] ICACHE_addr[22] ICACHE_addr[21]
+ ICACHE_addr[20] ICACHE_addr[19] ICACHE_addr[18] ICACHE_addr[17]
+ ICACHE_addr[16] ICACHE_addr[15] ICACHE_addr[14] ICACHE_addr[13]
+ ICACHE_addr[12] ICACHE_addr[11] ICACHE_addr[10] ICACHE_addr[9] ICACHE_addr[8]
+ ICACHE_addr[7] ICACHE_addr[6] ICACHE_addr[5] ICACHE_addr[4] ICACHE_addr[3]
+ ICACHE_addr[2] ICACHE_addr[1] ICACHE_addr[0] ICACHE_rdata[31]
+ ICACHE_rdata[30] ICACHE_rdata[29] ICACHE_rdata[28] ICACHE_rdata[27]
+ ICACHE_rdata[26] ICACHE_rdata[25] ICACHE_rdata[24] ICACHE_rdata[23]
+ ICACHE_rdata[22] ICACHE_rdata[21] ICACHE_rdata[20] ICACHE_rdata[19]
+ ICACHE_rdata[18] ICACHE_rdata[17] ICACHE_rdata[16] ICACHE_rdata[15]
+ ICACHE_rdata[14] ICACHE_rdata[13] ICACHE_rdata[12] ICACHE_rdata[11]
+ ICACHE_rdata[10] ICACHE_rdata[9] ICACHE_rdata[8] ICACHE_rdata[7]
+ ICACHE_rdata[6] ICACHE_rdata[5] ICACHE_rdata[4] ICACHE_rdata[3]
+ ICACHE_rdata[2] ICACHE_rdata[1] ICACHE_rdata[0] ICACHE_ren ICACHE_wen
+ ICACHE_wdata[31] ICACHE_wdata[30] ICACHE_wdata[29] ICACHE_wdata[28]
+ ICACHE_wdata[27] ICACHE_wdata[26] ICACHE_wdata[25] ICACHE_wdata[24]
+ ICACHE_wdata[23] ICACHE_wdata[22] ICACHE_wdata[21] ICACHE_wdata[20]
+ ICACHE_wdata[19] ICACHE_wdata[18] ICACHE_wdata[17] ICACHE_wdata[16]
+ ICACHE_wdata[15] ICACHE_wdata[14] ICACHE_wdata[13] ICACHE_wdata[12]
+ ICACHE_wdata[11] ICACHE_wdata[10] ICACHE_wdata[9] ICACHE_wdata[8]
+ ICACHE_wdata[7] ICACHE_wdata[6] ICACHE_wdata[5] ICACHE_wdata[4]
+ ICACHE_wdata[3] ICACHE_wdata[2] ICACHE_wdata[1] ICACHE_wdata[0] ICACHE_stall
+ DCACHE_addr[31] DCACHE_addr[30] DCACHE_addr[29] DCACHE_addr[28]
+ DCACHE_addr[27] DCACHE_addr[26] DCACHE_addr[25] DCACHE_addr[24]
+ DCACHE_addr[23] DCACHE_addr[22] DCACHE_addr[21] DCACHE_addr[20]
+ DCACHE_addr[19] DCACHE_addr[18] DCACHE_addr[17] DCACHE_addr[16]
+ DCACHE_addr[15] DCACHE_addr[14] DCACHE_addr[13] DCACHE_addr[12]
+ DCACHE_addr[11] DCACHE_addr[10] DCACHE_addr[9] DCACHE_addr[8] DCACHE_addr[7]
+ DCACHE_addr[6] DCACHE_addr[5] DCACHE_addr[4] DCACHE_addr[3] DCACHE_addr[2]
+ DCACHE_addr[1] DCACHE_addr[0] DCACHE_rdata[31] DCACHE_rdata[30]
+ DCACHE_rdata[29] DCACHE_rdata[28] DCACHE_rdata[27] DCACHE_rdata[26]
+ DCACHE_rdata[25] DCACHE_rdata[24] DCACHE_rdata[23] DCACHE_rdata[22]
+ DCACHE_rdata[21] DCACHE_rdata[20] DCACHE_rdata[19] DCACHE_rdata[18]
+ DCACHE_rdata[17] DCACHE_rdata[16] DCACHE_rdata[15] DCACHE_rdata[14]
+ DCACHE_rdata[13] DCACHE_rdata[12] DCACHE_rdata[11] DCACHE_rdata[10]
+ DCACHE_rdata[9] DCACHE_rdata[8] DCACHE_rdata[7] DCACHE_rdata[6]
+ DCACHE_rdata[5] DCACHE_rdata[4] DCACHE_rdata[3] DCACHE_rdata[2]
+ DCACHE_rdata[1] DCACHE_rdata[0] DCACHE_ren DCACHE_wen DCACHE_wdata[31]
+ DCACHE_wdata[30] DCACHE_wdata[29] DCACHE_wdata[28] DCACHE_wdata[27]
+ DCACHE_wdata[26] DCACHE_wdata[25] DCACHE_wdata[24] DCACHE_wdata[23]
+ DCACHE_wdata[22] DCACHE_wdata[21] DCACHE_wdata[20] DCACHE_wdata[19]
+ DCACHE_wdata[18] DCACHE_wdata[17] DCACHE_wdata[16] DCACHE_wdata[15]
+ DCACHE_wdata[14] DCACHE_wdata[13] DCACHE_wdata[12] DCACHE_wdata[11]
+ DCACHE_wdata[10] DCACHE_wdata[9] DCACHE_wdata[8] DCACHE_wdata[7]
+ DCACHE_wdata[6] DCACHE_wdata[5] DCACHE_wdata[4] DCACHE_wdata[3]
+ DCACHE_wdata[2] DCACHE_wdata[1] DCACHE_wdata[0] DCACHE_stall test_si test_so
+ test_se clk_i__L3_N1 clk_i__L3_N10 clk_i__L3_N11 clk_i__L3_N12 clk_i__L3_N13
+ clk_i__L3_N14 clk_i__L3_N15 clk_i__L3_N16 clk_i__L3_N17 clk_i__L3_N18
+ clk_i__L3_N19 clk_i__L3_N2 clk_i__L3_N20 clk_i__L3_N21 clk_i__L3_N22
+ clk_i__L3_N23 clk_i__L3_N24 clk_i__L3_N25 clk_i__L3_N26 clk_i__L3_N27
+ clk_i__L3_N3 clk_i__L3_N4 clk_i__L3_N5 clk_i__L3_N6 clk_i__L3_N7 clk_i__L3_N8
+ clk_i__L3_N9
*.CONNECT ICACHE_wdata[0] VSS
*.CONNECT ICACHE_wdata[1] VSS
*.CONNECT ICACHE_wdata[2] VSS
*.CONNECT ICACHE_wdata[3] VSS
*.CONNECT ICACHE_wdata[4] VSS
*.CONNECT ICACHE_wdata[5] VSS
*.CONNECT ICACHE_wdata[6] VSS
*.CONNECT ICACHE_wdata[7] VSS
*.CONNECT ICACHE_wdata[8] VSS
*.CONNECT ICACHE_wdata[9] VSS
*.CONNECT ICACHE_wdata[10] VSS
*.CONNECT ICACHE_wdata[11] VSS
*.CONNECT ICACHE_wdata[12] VSS
*.CONNECT ICACHE_wdata[13] VSS
*.CONNECT ICACHE_wdata[14] VSS
*.CONNECT ICACHE_wdata[15] VSS
*.CONNECT ICACHE_wdata[16] VSS
*.CONNECT ICACHE_wdata[17] VSS
*.CONNECT ICACHE_wdata[18] VSS
*.CONNECT ICACHE_wdata[19] VSS
*.CONNECT ICACHE_wdata[20] VSS
*.CONNECT ICACHE_wdata[21] VSS
*.CONNECT ICACHE_wdata[22] VSS
*.CONNECT ICACHE_wdata[23] VSS
*.CONNECT ICACHE_wdata[24] VSS
*.CONNECT ICACHE_wdata[25] VSS
*.CONNECT ICACHE_wdata[26] VSS
*.CONNECT ICACHE_wdata[27] VSS
*.CONNECT ICACHE_wdata[28] VSS
*.CONNECT ICACHE_wdata[29] VSS
*.CONNECT ICACHE_wdata[30] VSS
*.CONNECT ICACHE_wdata[31] VSS
*.CONNECT ICACHE_wen VSS
*.CONNECT ICACHE_ren VDD
XDIODE_1 ANTENNA $PINS A=test_se
XFE_OFC212_n276 CLKBUFX2 $PINS Y=FE_OFN212_n276 A=n276
XFE_OFC203_n279 CLKBUFX2 $PINS Y=FE_OFN203_n279 A=n279
XFE_OFC116_test_se_i CLKBUFX2 $PINS Y=FE_OFN116_test_se_i A=FE_OFN114_test_se_i
XFE_OFC114_test_se_i CLKBUFX2 $PINS Y=FE_OFN114_test_se_i A=test_se
XFE_OFC113_test_se_i CLKBUFX2 $PINS Y=FE_OFN113_test_se_i A=FE_OFN0_test_se_i
XFE_OFC110_test_se_i CLKBUFX2 $PINS Y=FE_OFN110_test_se_i A=FE_OFN109_test_se_i
XFE_OFC109_test_se_i CLKBUFX2 $PINS Y=FE_OFN109_test_se_i A=FE_OFN108_test_se_i
XFE_OFC108_test_se_i CLKBUFX2 $PINS Y=FE_OFN108_test_se_i A=FE_OFN8_test_se_i
XFE_OFC106_test_se_i CLKBUFX2 $PINS Y=FE_OFN106_test_se_i A=FE_OFN20_test_se_i
XFE_OFC105_test_se_i CLKBUFX2 $PINS Y=FE_OFN105_test_se_i A=FE_OFN104_test_se_i
XFE_OFC104_test_se_i CLKBUFX2 $PINS Y=FE_OFN104_test_se_i A=FE_OFN103_test_se_i
XFE_OFC103_test_se_i CLKBUFX2 $PINS Y=FE_OFN103_test_se_i A=FE_OFN23_test_se_i
XFE_OFC102_test_se_i CLKBUFX2 $PINS Y=FE_OFN102_test_se_i A=FE_OFN15_test_se_i
XFE_OFC101_test_se_i CLKBUFX2 $PINS Y=FE_OFN101_test_se_i A=FE_OFN100_test_se_i
XFE_OFC100_test_se_i CLKBUFX2 $PINS Y=FE_OFN100_test_se_i A=FE_OFN99_test_se_i
XFE_OFC99_test_se_i CLKBUFX2 $PINS Y=FE_OFN99_test_se_i A=FE_OFN21_test_se_i
XFE_OFC97_test_se_i CLKBUFX2 $PINS Y=FE_OFN97_test_se_i A=FE_OFN96_test_se_i
XFE_OFC96_test_se_i CLKBUFX2 $PINS Y=FE_OFN96_test_se_i A=FE_OFN14_test_se_i
XFE_OFC94_test_se_i CLKBUFX2 $PINS Y=FE_OFN94_test_se_i A=FE_OFN93_test_se_i
XFE_OFC93_test_se_i CLKBUFX2 $PINS Y=FE_OFN93_test_se_i A=FE_OFN15_test_se_i
XFE_OFC75_test_se_i CLKBUFX2 $PINS Y=FE_OFN75_test_se_i A=FE_OFN74_test_se_i
XFE_OFC74_test_se_i CLKBUFX2 $PINS Y=FE_OFN74_test_se_i A=FE_OFN7_test_se_i
XFE_OFC54_test_se_i CLKBUFX2 $PINS Y=FE_OFN54_test_se_i A=FE_OFN53_test_se_i
XFE_OFC53_test_se_i CLKBUFX2 $PINS Y=FE_OFN53_test_se_i A=FE_OFN4_test_se_i
XFE_OFC51_test_se_i CLKBUFX2 $PINS Y=FE_OFN51_test_se_i A=FE_OFN5_test_se_i
XFE_OFC28_EX_MEM_MEMControl_1_ CLKBUFX2 $PINS Y=FE_OFN28_EX_MEM_MEMControl_1_
+ A=EX_MEM_MEMControl[1]
XFE_OFC27_EX_MEM_MEMControl_0_ CLKBUFX2 $PINS Y=FE_OFN27_EX_MEM_MEMControl_0_
+ A=EX_MEM_MEMControl[0]
XFE_OFC23_test_se_i CLKBUFX3 $PINS Y=FE_OFN23_test_se_i A=FE_OFN8_test_se_i
XFE_OFC21_test_se_i CLKBUFX3 $PINS Y=FE_OFN21_test_se_i A=FE_OFN102_test_se_i
XFE_OFC20_test_se_i CLKBUFX3 $PINS Y=FE_OFN20_test_se_i A=FE_OFN8_test_se_i
XFE_OFC18_test_se_i CLKBUFX3 $PINS Y=FE_OFN18_test_se_i A=FE_OFN75_test_se_i
XFE_OFC15_test_se_i INVX1 $PINS Y=FE_OFN15_test_se_i A=FE_OFN2_test_se_i
XFE_OFC14_test_se_i INVX1 $PINS Y=FE_OFN14_test_se_i A=FE_OFN2_test_se_i
XFE_OFC8_test_se_i CLKINVX3 $PINS Y=FE_OFN8_test_se_i A=FE_OFN2_test_se_i
XFE_OFC7_test_se_i CLKBUFX3 $PINS Y=FE_OFN7_test_se_i A=FE_OFN1_test_se_i
XFE_OFC5_test_se_i CLKBUFX3 $PINS Y=FE_OFN5_test_se_i A=FE_OFN116_test_se_i
XFE_OFC4_test_se_i CLKBUFX3 $PINS Y=FE_OFN4_test_se_i A=FE_OFN116_test_se_i
XFE_OFC2_test_se_i CLKINVX1 $PINS Y=FE_OFN2_test_se_i A=FE_OFN113_test_se_i
XFE_OFC1_test_se_i CLKBUFX3 $PINS Y=FE_OFN1_test_se_i A=FE_OFN116_test_se_i
XFE_OFC0_test_se_i CLKBUFX3 $PINS Y=FE_OFN0_test_se_i A=test_se
XU269 CLKBUFX3 $PINS Y=n286 A=Instruction[17]
XU270 CLKBUFX3 $PINS Y=n291 A=Instruction[22]
XU271 OAI31XL $PINS Y=n298 B0=EX_MEM_WBControl[1] A2=EX_MEM_RegisterRd[3]
+ A1=EX_MEM_RegisterRd[4] A0=n297
XU272 CLKINVX1 $PINS Y=n314 A=EX_MEM_RegisterRd[3]
XU273 CLKINVX1 $PINS Y=n323 A=MEM_WB_RegisterRd[4]
XU274 OA21XL $PINS Y=n327 B0=MEM_WB_WBControl[1] A1=MEM_WB_RegisterRd[3]
+ A0=n242
XU275 XOR2X1 $PINS Y=n305 B=ID_EX_RegisterRt[4] A=n323
XU276 XOR2X1 $PINS Y=n304 B=ID_EX_RegisterRt[4] A=n315
XU277 XOR2X1 $PINS Y=n303 B=ID_EX_RegisterRt[0] A=n313
XU278 CLKINVX1 $PINS Y=n311 A=EX_MEM_RegisterRd[2]
XU279 XOR2X1 $PINS Y=n300 B=ID_EX_RegisterRt[3] A=n314
XU280 CLKINVX1 $PINS Y=n313 A=EX_MEM_RegisterRd[0]
XU281 XOR2X1 $PINS Y=n81 B=n291 A=ID_EX_RegisterRt[1]
XU282 NOR2X1 $PINS Y=ForwardB[0] B=n238 A=n309
XU283 OR2X1 $PINS Y=IF_Flush B=n276 A=PredictMiss
XU284 CLKMX2X2 $PINS Y=n269 S0=n279 B=MemoryData[9] A=Buf_ALUresult[9]
XU285 CLKINVX1 $PINS Y=n335 A=n74
XU286 CLKINVX1 $PINS Y=n315 A=EX_MEM_RegisterRd[4]
XU287 OR3XL $PINS Y=n204 C=n291 B=n293 A=n292
XU288 CLKBUFX8 $PINS Y=n288 A=Instruction[19]
XU289 CLKBUFX3 $PINS Y=n285 A=Instruction[16]
XU290 CLKBUFX3 $PINS Y=n290 A=Instruction[21]
XU291 BUFX4 $PINS Y=n292 A=Instruction[23]
XU292 CLKBUFX4 $PINS Y=n287 A=Instruction[18]
XU293 BUFX4 $PINS Y=n293 A=Instruction[24]
XU294 CLKBUFX4 $PINS Y=n294 A=Instruction[25]
XU295 CLKBUFX4 $PINS Y=n289 A=Instruction[20]
XU296 CLKBUFX3 $PINS Y=n295 A=needStall
XU297 XNOR2X1 $PINS Y=n237 B=ID_EX_RegisterRt[1] A=MEM_WB_RegisterRd[1]
XU298 OR3X2 $PINS Y=n238 C=n307 B=n308 A=n306
XU299 CLKINVX1 $PINS Y=n312 A=EX_MEM_RegisterRd[1]
XU300 NAND3BX1 $PINS Y=n297 C=n311 B=n313 AN=EX_MEM_RegisterRd[1]
XU301 BUFX12 $PINS Y=DCACHE_ren A=N199
XU302 NOR2BX1 $PINS Y=N199 B=FE_OFN27_EX_MEM_MEMControl_0_
+ AN=FE_OFN28_EX_MEM_MEMControl_1_
XU303 BUFX12 $PINS Y=DCACHE_wen A=N202
XU304 NOR2BX1 $PINS Y=N202 B=FE_OFN28_EX_MEM_MEMControl_1_
+ AN=FE_OFN27_EX_MEM_MEMControl_0_
XU305 OR4X1 $PINS Y=n242 D=MEM_WB_RegisterRd[2] C=MEM_WB_RegisterRd[0]
+ B=MEM_WB_RegisterRd[1] A=MEM_WB_RegisterRd[4]
XU306 MX2X1 $PINS Y=n266 S0=n279 B=MemoryData[4] A=Buf_ALUresult[4]
XU307 INVX1 $PINS Y=n322 A=n298
XU308 AND3X2 $PINS Y=n302 C=n299 B=n300 A=n301
XU309 CLKMX2X2 $PINS Y=n272 S0=FE_OFN203_n279 B=MemoryData[13]
+ A=Buf_ALUresult[13]
XU310 INVXL $PINS Y=n324 A=MEM_WB_RegisterRd[1]
XU311 NAND4X1 $PINS Y=n310 D=n302 C=n303 B=n304 A=n322
XU312 CLKMX2X2 $PINS Y=PCJump_JRChecked[25] S0=FE_OFN212_n276
+ B=next_ReadData1[25] A=PCbranched[25]
XU313 NAND4X1 $PINS Y=n309 D=n237 C=n305 B=n310 A=n327
XU314 XOR2XL $PINS Y=n301 B=ID_EX_RegisterRt[1] A=n312
XU315 AO22X1 $PINS Y=PCJump_JRChecked[15] B1=FE_OFN212_n276
+ B0=next_ReadData1[15] A1=n75 A0=PCbranched[15]
XU316 XOR2XL $PINS Y=n299 B=ID_EX_RegisterRt[2] A=n311
XU317 CLKMX2X2 $PINS Y=n250 S0=FE_OFN203_n279 B=MemoryData[20]
+ A=Buf_ALUresult[20]
XU318 MX2X1 $PINS Y=n254 S0=FE_OFN203_n279 B=MemoryData[24] A=Buf_ALUresult[24]
XU319 AO22X1 $PINS Y=PCJump_JRChecked[21] B1=FE_OFN212_n276
+ B0=next_ReadData1[21] A1=n75 A0=PCbranched[21]
XU320 AO22X1 $PINS Y=PCJump_JRChecked[9] B1=n276 B0=next_ReadData1[9] A1=n75
+ A0=PCbranched[9]
XU321 AO22X1 $PINS Y=PCJump_JRChecked[5] B1=n276 B0=next_ReadData1[5] A1=n75
+ A0=PCbranched[5]
XU322 CLKMX2X2 $PINS Y=n262 S0=n279 B=MemoryData[0] A=Buf_ALUresult[0]
XU323 CLKMX2X2 $PINS Y=n243 S0=FE_OFN203_n279 B=MemoryData[11]
+ A=Buf_ALUresult[11]
XU324 AO22X1 $PINS Y=PCJump_JRChecked[17] B1=FE_OFN212_n276
+ B0=next_ReadData1[17] A1=n275 A0=PCbranched[17]
XU325 AO22X1 $PINS Y=PCJump_JRChecked[23] B1=FE_OFN212_n276
+ B0=next_ReadData1[23] A1=n275 A0=PCbranched[23]
XU326 OA21XL $PINS Y=BrForwardB[1] B0=Branch A1=n128 A0=n127
XU327 OA21XL $PINS Y=BrForwardA[1] B0=Branch A1=n156 A0=n155
XU328 OA21XL $PINS Y=BrForwardB[0] B0=Branch A1=n128 A0=n129
XU329 OA21XL $PINS Y=BrForwardA[0] B0=Branch A1=n156 A0=n157
XU330 CLKINVX1 $PINS Y=n333 A=n73
XU331 NAND4XL $PINS Y=n332 D=n319 C=n320 B=n321 A=n322
XU332 XOR2XL $PINS Y=n320 B=ID_EX_RegisterRs[1] A=n312
XU333 XOR2XL $PINS Y=n321 B=ID_EX_RegisterRs[2] A=n311
XU334 XOR2XL $PINS Y=n316 B=ID_EX_RegisterRs[4] A=n315
XU335 XOR2XL $PINS Y=n318 B=ID_EX_RegisterRs[0] A=n313
XU336 XOR2XL $PINS Y=n317 B=ID_EX_RegisterRs[3] A=n314
XU337 MX2X1 $PINS Y=n274 S0=FE_OFN203_n279 B=MemoryData[14] A=Buf_ALUresult[14]
XU338 CLKMX2X2 $PINS Y=n261 S0=n279 B=MemoryData[1] A=Buf_ALUresult[1]
XU339 CLKMX2X2 $PINS Y=n246 S0=FE_OFN203_n279 B=MemoryData[16]
+ A=Buf_ALUresult[16]
XU340 XOR2XL $PINS Y=n151 B=ID_EX_RegisterRd[2] A=n287
XU341 XOR2XL $PINS Y=n180 B=ID_EX_RegisterRd[2] A=n292
XU342 XOR2XL $PINS Y=n152 B=ID_EX_RegisterRd[3] A=n288
XU343 XOR2XL $PINS Y=n181 B=ID_EX_RegisterRd[3] A=n293
XU344 XNOR2XL $PINS Y=n148 B=n286 A=ID_EX_RegisterRd[1]
XU345 XNOR2XL $PINS Y=n177 B=n291 A=ID_EX_RegisterRd[1]
XU346 NOR3XL $PINS Y=Jump C=n353 B=Instruction[28] A=n91
XU347 CLKMX2X2 $PINS Y=n248 S0=FE_OFN203_n279 B=MemoryData[18]
+ A=Buf_ALUresult[18]
XU348 CLKMX2X2 $PINS Y=n252 S0=FE_OFN203_n279 B=MemoryData[22]
+ A=Buf_ALUresult[22]
XU349 CLKMX2X2 $PINS Y=n251 S0=FE_OFN203_n279 B=MemoryData[23]
+ A=Buf_ALUresult[23]
XU350 CLKMX2X2 $PINS Y=n247 S0=FE_OFN203_n279 B=MemoryData[19]
+ A=Buf_ALUresult[19]
XU351 CLKMX2X2 $PINS Y=n249 S0=FE_OFN203_n279 B=MemoryData[21]
+ A=Buf_ALUresult[21]
XU352 CLKMX2X2 $PINS Y=n245 S0=FE_OFN203_n279 B=MemoryData[17]
+ A=Buf_ALUresult[17]
XU353 MX2X1 $PINS Y=n256 S0=FE_OFN203_n279 B=MemoryData[26] A=Buf_ALUresult[26]
XU354 CLKMX2X2 $PINS Y=n255 S0=FE_OFN203_n279 B=MemoryData[27]
+ A=Buf_ALUresult[27]
XU355 CLKMX2X2 $PINS Y=n259 S0=n279 B=MemoryData[31] A=Buf_ALUresult[31]
XU356 CLKMX2X2 $PINS Y=n260 S0=n279 B=MemoryData[30] A=Buf_ALUresult[30]
XU357 CLKMX2X2 $PINS Y=n257 S0=FE_OFN203_n279 B=MemoryData[29]
+ A=Buf_ALUresult[29]
XU358 CLKMX2X2 $PINS Y=n258 S0=n279 B=MemoryData[28] A=Buf_ALUresult[28]
XU359 AOI211XL $PINS Y=n144 C0=n344 B0=n153 A1=n345 A0=n77
XU360 AOI211XL $PINS Y=n173 C0=n344 B0=n182 A1=n345 A0=n80
XU361 XOR2XL $PINS Y=n140 B=n288 A=MEM_WB_RegisterRd[3]
XU362 XOR2XL $PINS Y=n169 B=n293 A=MEM_WB_RegisterRd[3]
XU363 NOR3XL $PINS Y=n159 C=n91 B=Instruction[27] A=Instruction[26]
XU364 INVX1 $PINS Y=n352 A=Instruction[28]
XU365 INVX1 $PINS Y=n353 A=Instruction[27]
XU366 INVX1 $PINS Y=n350 A=Instruction[29]
XU367 INVXL $PINS Y=n349 A=Instruction[30]
XU368 XNOR2XL $PINS Y=n134 B=n286 A=EX_MEM_RegisterRd[1]
XU369 XNOR2XL $PINS Y=n136 B=n285 A=EX_MEM_RegisterRd[0]
XU370 XNOR2XL $PINS Y=n135 B=n289 A=EX_MEM_RegisterRd[4]
XU371 XNOR2XL $PINS Y=n163 B=n291 A=EX_MEM_RegisterRd[1]
XU372 XNOR2XL $PINS Y=n164 B=n294 A=EX_MEM_RegisterRd[4]
XU373 XNOR2XL $PINS Y=n165 B=n290 A=EX_MEM_RegisterRd[0]
XU374 XOR2XL $PINS Y=n143 B=n289 A=MEM_WB_RegisterRd[4]
XU375 XOR2XL $PINS Y=n172 B=n294 A=MEM_WB_RegisterRd[4]
XU376 XOR2XL $PINS Y=n138 B=EX_MEM_RegisterRd[2] A=n287
XU377 XOR2XL $PINS Y=n139 B=EX_MEM_RegisterRd[3] A=n288
XU378 XOR2XL $PINS Y=n167 B=EX_MEM_RegisterRd[2] A=n292
XU379 XOR2XL $PINS Y=n168 B=EX_MEM_RegisterRd[3] A=n293
XU380 XOR2XL $PINS Y=n146 B=ID_EX_RegisterRd[0] A=n285
XU381 XOR2XL $PINS Y=n175 B=ID_EX_RegisterRd[0] A=n290
XU382 XOR2XL $PINS Y=n171 B=n290 A=MEM_WB_RegisterRd[0]
XU383 XOR2XL $PINS Y=n142 B=n285 A=MEM_WB_RegisterRd[0]
XU384 XOR2XL $PINS Y=n141 B=n286 A=MEM_WB_RegisterRd[1]
XU385 XOR2XL $PINS Y=n170 B=n291 A=MEM_WB_RegisterRd[1]
XU386 XOR2XL $PINS Y=n162 B=n292 A=MEM_WB_RegisterRd[2]
XU387 XOR2XL $PINS Y=n133 B=n287 A=MEM_WB_RegisterRd[2]
XU388 INVXL $PINS Y=n347 A=Instruction[31]
XU389 XNOR2XL $PINS Y=n154 B=n289 A=ID_EX_RegisterRd[4]
XU390 XNOR2XL $PINS Y=n183 B=n294 A=ID_EX_RegisterRd[4]
XU391 INVXL $PINS Y=n343 A=EX_MEM_WBControl[1]
XU392 INVXL $PINS Y=n342 A=MEM_WB_WBControl[1]
XU393 NOR3XL $PINS Y=n196 C=Instruction[3] B=Instruction[6] A=n294
XU394 NOR4XL $PINS Y=n198 D=n289 C=n290 B=n288 A=n204
XU395 NOR3XL $PINS Y=n192 C=n350 B=Instruction[31] A=Instruction[30]
XU396 OAI31XL $PINS Y=n189 B0=n191 A2=n353 A1=n352 A0=n348
XU397 NAND4XL $PINS Y=n191 D=n353 C=Instruction[28] B=Instruction[26] A=n192
XU398 AOI2BB2XL $PINS Y=n193 B1=n347 B0=Instruction[27] A1N=n352 A0N=n348
XU399 NAND2XL $PINS Y=n184 B=Instruction[27] A=n188
XU400 NAND2XL $PINS Y=n195 B=n352 A=Instruction[26]
XU401 NAND4XL $PINS Y=n89 D=n351 C=n186 B=Instruction[27] A=Instruction[31]
XU402 NOR2XL $PINS Y=n186 B=Instruction[29] A=Instruction[30]
XU403 NAND4XL $PINS Y=n90 D=n187 C=Instruction[27] B=n349 A=n351
XU404 XOR2XL $PINS Y=n308 B=MEM_WB_RegisterRd[2] A=ID_EX_RegisterRt[2]
XU405 XOR2XL $PINS Y=n307 B=MEM_WB_RegisterRd[0] A=ID_EX_RegisterRt[0]
XU406 XOR2XL $PINS Y=n306 B=MEM_WB_RegisterRd[3] A=ID_EX_RegisterRt[3]
XU407 CLKINVX1 $PINS Y=n276 A=n275
XU409 CLKINVX1 $PINS Y=n55 A=n185
XU410 CLKINVX1 $PINS Y=ForwardB[1] A=n310
XU411 AO22X1 $PINS Y=PCJump_JRChecked[6] B1=n276 B0=next_ReadData1[6] A1=n275
+ A0=PCbranched[6]
XU412 CLKMX2X2 $PINS Y=PCJump_JRChecked[27] S0=FE_OFN212_n276
+ B=next_ReadData1[27] A=PCbranched[27]
XU413 AO22X1 $PINS Y=PCJump_JRChecked[11] B1=n276 B0=next_ReadData1[11] A1=n275
+ A0=PCbranched[11]
XU414 CLKMX2X2 $PINS Y=PCJump_JRChecked[29] S0=FE_OFN212_n276
+ B=next_ReadData1[29] A=PCbranched[29]
XU415 CLKMX2X2 $PINS Y=PCJump_JRChecked[28] S0=FE_OFN212_n276
+ B=next_ReadData1[28] A=PCbranched[28]
XU416 AO22X1 $PINS Y=PCJump_JRChecked[16] B1=FE_OFN212_n276
+ B0=next_ReadData1[16] A1=n275 A0=PCbranched[16]
XU417 AO22X1 $PINS Y=PCJump_JRChecked[18] B1=FE_OFN212_n276
+ B0=next_ReadData1[18] A1=n275 A0=PCbranched[18]
XU418 AO22X1 $PINS Y=PCJump_JRChecked[19] B1=FE_OFN212_n276
+ B0=next_ReadData1[19] A1=n275 A0=PCbranched[19]
XU419 AO22X1 $PINS Y=PCJump_JRChecked[20] B1=FE_OFN212_n276
+ B0=next_ReadData1[20] A1=n275 A0=PCbranched[20]
XU420 AO22X1 $PINS Y=PCJump_JRChecked[22] B1=FE_OFN212_n276
+ B0=next_ReadData1[22] A1=n275 A0=PCbranched[22]
XU421 AO22X1 $PINS Y=PCJump_JRChecked[24] B1=FE_OFN212_n276
+ B0=next_ReadData1[24] A1=n275 A0=PCbranched[24]
XU422 AO22X1 $PINS Y=PCJump_JRChecked[8] B1=n276 B0=next_ReadData1[8] A1=n75
+ A0=PCbranched[8]
XU423 AO22X1 $PINS Y=PCJump_JRChecked[10] B1=n276 B0=next_ReadData1[10] A1=n275
+ A0=PCbranched[10]
XU424 AO22X1 $PINS Y=PCJump_JRChecked[12] B1=FE_OFN212_n276
+ B0=next_ReadData1[12] A1=n275 A0=PCbranched[12]
XU425 AO22X1 $PINS Y=PCJump_JRChecked[14] B1=FE_OFN212_n276
+ B0=next_ReadData1[14] A1=n275 A0=PCbranched[14]
XU426 AO22X1 $PINS Y=PCJump_JRChecked[7] B1=n276 B0=next_ReadData1[7] A1=n275
+ A0=PCbranched[7]
XU427 AO22X1 $PINS Y=PCJump_JRChecked[13] B1=FE_OFN212_n276
+ B0=next_ReadData1[13] A1=n275 A0=PCbranched[13]
XU428 CLKMX2X2 $PINS Y=PCJump_JRChecked[26] S0=FE_OFN212_n276
+ B=next_ReadData1[26] A=PCbranched[26]
XU429 CLKINVX1 $PINS Y=ForwardA[1] A=n332
XU430 NAND3X1 $PINS Y=n91 C=n350 B=n347 A=n349
XU432 CLKBUFX3 $PINS Y=n279 A=MEM_WB_WBControl[0]
XU433 AO22X1 $PINS Y=PCJump_JRChecked[2] B1=n276 B0=next_ReadData1[2] A1=n275
+ A0=PCbranched[2]
XU434 AO22X1 $PINS Y=PCJump_JRChecked[3] B1=n276 B0=next_ReadData1[3] A1=n275
+ A0=PCbranched[3]
XU435 NOR2BX1 $PINS Y=Branch B=n352 AN=n159
XU436 NOR2X1 $PINS Y=n127 B=n130 A=n129
XU437 NOR2X1 $PINS Y=n155 B=n158 A=n157
XU438 AOI21X1 $PINS Y=n185 B0=n189 A1=n188 A0=n353
XU439 AOI21X1 $PINS Y=n241 B0=n333 A1=n334 A0=n335
XU440 NAND2X1 $PINS Y=n190 B=n352 A=n159
XU441 CLKINVX1 $PINS Y=n334 A=n189
XU442 NAND2X1 $PINS Y=n74 B=n184 A=n190
XU443 CLKINVX1 $PINS Y=n348 A=n188
XU444 CLKBUFX3 $PINS Y=n275 A=n75
XU445 CLKINVX1 $PINS Y=n351 A=n195
XU446 OR3X2 $PINS Y=n202 C=n285 B=n287 A=n286
XU447 CLKINVX1 $PINS Y=n57 A=n89
XU448 AO22X1 $PINS Y=PCJump_JRChecked[4] B1=n276 B0=next_ReadData1[4] A1=n75
+ A0=PCbranched[4]
XU449 AO22X1 $PINS Y=PCJump_JRChecked[0] B1=n276 B0=next_ReadData1[0] A1=n275
+ A0=PCbranched[0]
XU450 AO22X1 $PINS Y=PCJump_JRChecked[1] B1=n276 B0=next_ReadData1[1] A1=n275
+ A0=PCbranched[1]
XU451 CLKMX2X2 $PINS Y=PCJump_JRChecked[31] S0=FE_OFN212_n276
+ B=next_ReadData1[31] A=PCbranched[31]
XU452 CLKMX2X2 $PINS Y=PCJump_JRChecked[30] S0=FE_OFN212_n276
+ B=next_ReadData1[30] A=PCbranched[30]
XU453 NOR4X1 $PINS Y=ForwardA[0] D=n328 C=n329 B=n330 A=n331
XU454 XOR2X1 $PINS Y=n330 B=MEM_WB_RegisterRd[2] A=ID_EX_RegisterRs[2]
XU455 XOR2X1 $PINS Y=n328 B=MEM_WB_RegisterRd[3] A=ID_EX_RegisterRs[3]
XU456 XOR2X1 $PINS Y=n329 B=MEM_WB_RegisterRd[0] A=ID_EX_RegisterRs[0]
XU457 AND3X2 $PINS Y=n319 C=n316 B=n317 A=n318
XU458 NAND4X1 $PINS Y=n331 D=n325 C=n326 B=n332 A=n327
XU459 XOR2X1 $PINS Y=n326 B=ID_EX_RegisterRs[4] A=n323
XU460 XOR2X1 $PINS Y=n325 B=ID_EX_RegisterRs[1] A=n324
XU461 CLKMX2X2 $PINS Y=n244 S0=FE_OFN203_n279 B=MemoryData[15]
+ A=Buf_ALUresult[15]
XU462 XOR2X1 $PINS Y=n87 B=Instruction[19] A=ID_EX_RegisterRt[3]
XU463 XOR2X1 $PINS Y=n84 B=Instruction[24] A=ID_EX_RegisterRt[3]
XU464 XOR2X1 $PINS Y=n85 B=Instruction[23] A=ID_EX_RegisterRt[2]
XU465 XOR2X1 $PINS Y=n88 B=Instruction[18] A=ID_EX_RegisterRt[2]
XU466 XOR2X1 $PINS Y=n80 B=Instruction[25] A=ID_EX_RegisterRt[4]
XU467 XOR2X1 $PINS Y=n77 B=Instruction[20] A=ID_EX_RegisterRt[4]
XU468 XOR2X1 $PINS Y=n78 B=n286 A=ID_EX_RegisterRt[1]
XU469 XOR2X1 $PINS Y=n83 B=n290 A=ID_EX_RegisterRt[0]
XU470 XOR2X1 $PINS Y=n86 B=n285 A=ID_EX_RegisterRt[0]
XU471 CLKMX2X2 $PINS Y=n253 S0=FE_OFN203_n279 B=MemoryData[25]
+ A=Buf_ALUresult[25]
XU472 CLKMX2X2 $PINS Y=n263 S0=n279 B=MemoryData[3] A=Buf_ALUresult[3]
XU473 CLKMX2X2 $PINS Y=n264 S0=n279 B=MemoryData[2] A=Buf_ALUresult[2]
XU474 CLKMX2X2 $PINS Y=n265 S0=n279 B=MemoryData[5] A=Buf_ALUresult[5]
XU475 CLKMX2X2 $PINS Y=n267 S0=n279 B=MemoryData[7] A=Buf_ALUresult[7]
XU476 CLKMX2X2 $PINS Y=n268 S0=n279 B=MemoryData[6] A=Buf_ALUresult[6]
XU477 CLKMX2X2 $PINS Y=n270 S0=n279 B=MemoryData[8] A=Buf_ALUresult[8]
XU478 CLKMX2X2 $PINS Y=n271 S0=FE_OFN203_n279 B=MemoryData[10]
+ A=Buf_ALUresult[10]
XU479 CLKMX2X2 $PINS Y=n273 S0=FE_OFN203_n279 B=MemoryData[12]
+ A=Buf_ALUresult[12]
XU480 AND2X2 $PINS Y=N182 B=n76 A=ID_EX_MEMControl[1]
XU481 OAI33X1 $PINS Y=n76 B2=n82 B1=n81 B0=n80 A2=n79 A1=n78 A0=n77
XU482 OR3X2 $PINS Y=n79 C=n88 B=n87 A=n86
XU483 OR3X2 $PINS Y=n82 C=n85 B=n84 A=n83
XU484 OR2X1 $PINS Y=needStall B=ICACHE_stall A=DCACHE_stall
XU485 CLKBUFX3 $PINS Y=n282 A=Immediate_SE[8]
XU486 CLKBUFX3 $PINS Y=n281 A=Immediate_SE[7]
XU487 CLKBUFX3 $PINS Y=n283 A=Immediate_SE[9]
XU488 CLKBUFX3 $PINS Y=n280 A=Immediate_SE[6]
XU489 CLKBUFX3 $PINS Y=n284 A=Immediate_SE[10]
XU490 OAI211X1 $PINS Y=n147 C0=n150 B0=n149 A1=n345 A0=n148
XU491 OAI21XL $PINS Y=n149 B0=ID_EX_EXControl[4] A1=n152 A0=n151
XU492 OAI21XL $PINS Y=n150 B0=n345 A1=n88 A0=n87
XU493 OAI211X1 $PINS Y=n176 C0=n179 B0=n178 A1=n345 A0=n177
XU494 OAI21XL $PINS Y=n178 B0=ID_EX_EXControl[4] A1=n181 A0=n180
XU495 OAI21XL $PINS Y=n179 B0=n345 A1=n85 A0=n84
XU496 NAND4X1 $PINS Y=n130 D=n137 C=n136 B=n135 A=n134
XU497 NAND4X1 $PINS Y=n158 D=n166 C=n165 B=n164 A=n163
XU498 CLKINVX1 $PINS Y=n345 A=ID_EX_EXControl[4]
XU499 NOR3X1 $PINS Y=n137 C=n139 B=n343 A=n138
XU500 NOR3X1 $PINS Y=n166 C=n168 B=n343 A=n167
XU501 AND2X2 $PINS Y=n129 B=n145 A=n144
XU502 AOI221XL $PINS Y=n145 C0=n147 B1=n146 B0=ID_EX_EXControl[4] A1=n345
+ A0=n78
XU503 OAI2BB2XL $PINS Y=n153 B1=n345 B0=n154 A1N=n86 A0N=n345
XU504 AND2X2 $PINS Y=n157 B=n174 A=n173
XU505 AOI221XL $PINS Y=n174 C0=n176 B1=n175 B0=ID_EX_EXControl[4] A1=n345
+ A0=n81
XU506 OAI2BB2XL $PINS Y=n182 B1=n345 B0=n183 A1N=n83 A0N=n345
XU507 CLKINVX1 $PINS Y=n344 A=ID_EX_WBControl[1]
XU508 AND2X2 $PINS Y=n128 B=n132 A=n131
XU509 NOR4X1 $PINS Y=n131 D=n143 C=n142 B=n141 A=n140
XU510 NOR4BX1 $PINS Y=n132 D=n133 C=n342 B=n129 AN=n130
XU511 AND2X2 $PINS Y=n156 B=n161 A=n160
XU512 NOR4X1 $PINS Y=n160 D=n172 C=n171 B=n170 A=n169
XU513 NOR4BX1 $PINS Y=n161 D=n162 C=n342 B=n157 AN=n158
XU514 NAND3BX1 $PINS Y=n75 C=n340 B=n241 AN=ALUOp[0]
XU515 AND3X2 $PINS Y=n340 C=n341 B=n185 A=Instruction[3]
XU516 NOR2BX1 $PINS Y=n188 B=Instruction[26] AN=n192
XU517 NAND4X1 $PINS Y=n73 D=n199 C=n198 B=n197 A=n196
XU518 NOR3X1 $PINS Y=n197 C=Instruction[8] B=Instruction[9] A=Instruction[7]
XU519 NAND4X1 $PINS Y=ALUOp[0] D=n194 C=n193 B=n349 A=n73
XU520 AOI222XL $PINS Y=n194 C1=n353 C0=n351 B1=n350 B0=Instruction[28] A1=n195
+ A0=Instruction[31]
XU521 AND4X1 $PINS Y=n199 D=n201 C=n200 B=n346 A=n341
XU522 NOR3X1 $PINS Y=n200 C=Instruction[11] B=Instruction[12] A=Instruction[10]
XU523 NOR4X1 $PINS Y=n201 D=Instruction[14] C=Instruction[15] B=Instruction[13]
+ A=n202
XU524 CLKINVX1 $PINS Y=n346 A=n190
XU525 CLKINVX1 $PINS Y=n341 A=n339
XU526 NAND4BX1 $PINS Y=n339 D=n336 C=n337 B=n338 AN=n203
XU527 CLKINVX1 $PINS Y=n337 A=Instruction[0]
XU528 CLKINVX1 $PINS Y=n336 A=Instruction[1]
XU529 CLKINVX1 $PINS Y=n338 A=Instruction[2]
XU530 NAND4X1 $PINS Y=ALUSrc D=n89 C=n90 B=n185 A=n184
XU531 CLKINVX1 $PINS Y=n56 A=n90
XU532 CLKINVX1 $PINS Y=n54 A=n72
XU533 AOI211X1 $PINS Y=n72 C0=n57 B0=n55 A1=n74 A0=n73
XU534 OR2X1 $PINS Y=n203 B=Instruction[4] A=Instruction[5]
XU535 NOR2X1 $PINS Y=n187 B=n350 A=n347
XU536 CLKBUFX4 $PINS Y=n296 A=rst
XIF InstructionFetch_test_1 $PINS clk=clk_i__L3_N24 rst=n296 stall=n295
+ PCWrite=N182 PCJumpJRorBranch[31]=PCJump_JRChecked[31]
+ PCJumpJRorBranch[30]=PCJump_JRChecked[30]
+ PCJumpJRorBranch[29]=PCJump_JRChecked[29]
+ PCJumpJRorBranch[28]=PCJump_JRChecked[28]
+ PCJumpJRorBranch[27]=PCJump_JRChecked[27]
+ PCJumpJRorBranch[26]=PCJump_JRChecked[26]
+ PCJumpJRorBranch[25]=PCJump_JRChecked[25]
+ PCJumpJRorBranch[24]=PCJump_JRChecked[24]
+ PCJumpJRorBranch[23]=PCJump_JRChecked[23]
+ PCJumpJRorBranch[22]=PCJump_JRChecked[22]
+ PCJumpJRorBranch[21]=PCJump_JRChecked[21]
+ PCJumpJRorBranch[20]=PCJump_JRChecked[20]
+ PCJumpJRorBranch[19]=PCJump_JRChecked[19]
+ PCJumpJRorBranch[18]=PCJump_JRChecked[18]
+ PCJumpJRorBranch[17]=PCJump_JRChecked[17]
+ PCJumpJRorBranch[16]=PCJump_JRChecked[16]
+ PCJumpJRorBranch[15]=PCJump_JRChecked[15]
+ PCJumpJRorBranch[14]=PCJump_JRChecked[14]
+ PCJumpJRorBranch[13]=PCJump_JRChecked[13]
+ PCJumpJRorBranch[12]=PCJump_JRChecked[12]
+ PCJumpJRorBranch[11]=PCJump_JRChecked[11]
+ PCJumpJRorBranch[10]=PCJump_JRChecked[10]
+ PCJumpJRorBranch[9]=PCJump_JRChecked[9] PCJumpJRorBranch[8]=PCJump_JRChecked[8]
+ PCJumpJRorBranch[7]=PCJump_JRChecked[7] PCJumpJRorBranch[6]=PCJump_JRChecked[6]
+ PCJumpJRorBranch[5]=PCJump_JRChecked[5] PCJumpJRorBranch[4]=PCJump_JRChecked[4]
+ PCJumpJRorBranch[3]=PCJump_JRChecked[3] PCJumpJRorBranch[2]=PCJump_JRChecked[2]
+ PCJumpJRorBranch[1]=PCJump_JRChecked[1] PCJumpJRorBranch[0]=PCJump_JRChecked[0]
+ IF_ID_Write=N182 IF_Flush=IF_Flush PCadd4[31]=PCadd4[31] PCadd4[30]=PCadd4[30]
+ PCadd4[29]=PCadd4[29] PCadd4[28]=PCadd4[28] PCadd4[27]=PCadd4[27]
+ PCadd4[26]=PCadd4[26] PCadd4[25]=PCadd4[25] PCadd4[24]=PCadd4[24]
+ PCadd4[23]=PCadd4[23] PCadd4[22]=PCadd4[22] PCadd4[21]=PCadd4[21]
+ PCadd4[20]=PCadd4[20] PCadd4[19]=PCadd4[19] PCadd4[18]=PCadd4[18]
+ PCadd4[17]=PCadd4[17] PCadd4[16]=PCadd4[16] PCadd4[15]=PCadd4[15]
+ PCadd4[14]=PCadd4[14] PCadd4[13]=PCadd4[13] PCadd4[12]=PCadd4[12]
+ PCadd4[11]=PCadd4[11] PCadd4[10]=PCadd4[10] PCadd4[9]=PCadd4[9]
+ PCadd4[8]=PCadd4[8] PCadd4[7]=PCadd4[7] PCadd4[6]=PCadd4[6] PCadd4[5]=PCadd4[5]
+ PCadd4[4]=PCadd4[4] PCadd4[3]=PCadd4[3] PCadd4[2]=PCadd4[2] PCadd4[1]=PCadd4[1]
+ PCadd4[0]=PCadd4[0] Instruction[31]=Instruction[31]
+ Instruction[30]=Instruction[30] Instruction[29]=Instruction[29]
+ Instruction[28]=Instruction[28] Instruction[27]=Instruction[27]
+ Instruction[26]=Instruction[26] Instruction[25]=Instruction[25]
+ Instruction[24]=Instruction[24] Instruction[23]=Instruction[23]
+ Instruction[22]=Instruction[22] Instruction[21]=Instruction[21]
+ Instruction[20]=Instruction[20] Instruction[19]=Instruction[19]
+ Instruction[18]=Instruction[18] Instruction[17]=Instruction[17]
+ Instruction[16]=Instruction[16] Instruction[15]=Instruction[15]
+ Instruction[14]=Instruction[14] Instruction[13]=Instruction[13]
+ Instruction[12]=Instruction[12] Instruction[11]=Instruction[11]
+ Instruction[10]=Instruction[10] Instruction[9]=Instruction[9]
+ Instruction[8]=Instruction[8] Instruction[7]=Instruction[7]
+ Instruction[6]=Instruction[6] Instruction[5]=Instruction[5]
+ Instruction[4]=Instruction[4] Instruction[3]=Instruction[3]
+ Instruction[2]=Instruction[2] Instruction[1]=Instruction[1]
+ Instruction[0]=Instruction[0] PC[31]=ICACHE_addr[31] PC[30]=ICACHE_addr[30]
+ PC[29]=ICACHE_addr[29] PC[28]=ICACHE_addr[28] PC[27]=ICACHE_addr[27]
+ PC[26]=ICACHE_addr[26] PC[25]=ICACHE_addr[25] PC[24]=ICACHE_addr[24]
+ PC[23]=ICACHE_addr[23] PC[22]=ICACHE_addr[22] PC[21]=ICACHE_addr[21]
+ PC[20]=ICACHE_addr[20] PC[19]=ICACHE_addr[19] PC[18]=ICACHE_addr[18]
+ PC[17]=ICACHE_addr[17] PC[16]=ICACHE_addr[16] PC[15]=ICACHE_addr[15]
+ PC[14]=ICACHE_addr[14] PC[13]=ICACHE_addr[13] PC[12]=ICACHE_addr[12]
+ PC[11]=ICACHE_addr[11] PC[10]=ICACHE_addr[10] PC[9]=ICACHE_addr[9]
+ PC[8]=ICACHE_addr[8] PC[7]=ICACHE_addr[7] PC[6]=ICACHE_addr[6]
+ PC[5]=ICACHE_addr[5] PC[4]=ICACHE_addr[4] PC[3]=ICACHE_addr[3]
+ PC[2]=ICACHE_addr[2] PC[1]=ICACHE_addr[1] PC[0]=ICACHE_addr[0]
+ read_Instruction[31]=ICACHE_rdata[31] read_Instruction[30]=ICACHE_rdata[30]
+ read_Instruction[29]=ICACHE_rdata[29] read_Instruction[28]=ICACHE_rdata[28]
+ read_Instruction[27]=ICACHE_rdata[27] read_Instruction[26]=ICACHE_rdata[26]
+ read_Instruction[25]=ICACHE_rdata[25] read_Instruction[24]=ICACHE_rdata[24]
+ read_Instruction[23]=ICACHE_rdata[23] read_Instruction[22]=ICACHE_rdata[22]
+ read_Instruction[21]=ICACHE_rdata[21] read_Instruction[20]=ICACHE_rdata[20]
+ read_Instruction[19]=ICACHE_rdata[19] read_Instruction[18]=ICACHE_rdata[18]
+ read_Instruction[17]=ICACHE_rdata[17] read_Instruction[16]=ICACHE_rdata[16]
+ read_Instruction[15]=ICACHE_rdata[15] read_Instruction[14]=ICACHE_rdata[14]
+ read_Instruction[13]=ICACHE_rdata[13] read_Instruction[12]=ICACHE_rdata[12]
+ read_Instruction[11]=ICACHE_rdata[11] read_Instruction[10]=ICACHE_rdata[10]
+ read_Instruction[9]=ICACHE_rdata[9] read_Instruction[8]=ICACHE_rdata[8]
+ read_Instruction[7]=ICACHE_rdata[7] read_Instruction[6]=ICACHE_rdata[6]
+ read_Instruction[5]=ICACHE_rdata[5] read_Instruction[4]=ICACHE_rdata[4]
+ read_Instruction[3]=ICACHE_rdata[3] read_Instruction[2]=ICACHE_rdata[2]
+ read_Instruction[1]=ICACHE_rdata[1] read_Instruction[0]=ICACHE_rdata[0]
+ PredictMiss=PredictMiss BranchTaken=BranchTaken PCBuffer_valid=PCBuffer_valid
+ test_si=n3 test_so=test_so test_se=FE_OFN106_test_se_i SPCASCAN_N0=SPCASCAN_N0
+ SPCASCAN_N1=SPCBSCAN_N38 SPCASCAN_N2=ICACHE_addr[9] SPCASCAN_N3=SPCASCAN_N2
+ SPCASCAN_N4=SPCASCAN_N4 SPCASCAN_N5=SPCASCAN_N5 SPCASCAN_N7=SPCASCAN_N7
+ SPCASCAN_N9=SPCASCAN_N9 SPCASCAN_N11=SPCASCAN_N11 SPCASCAN_N13=SPCASCAN_N13
+ SPCASCAN_N14=SPCASCAN_N14 SPCASCAN_N15=SPCASCAN_N15 SPCASCAN_N18=SPCASCAN_N18
+ SPCASCAN_N19=SPCASCAN_N19 SPCASCAN_N20=SPCASCAN_N20 SPCASCAN_N23=SPCASCAN_N27
+ SPCASCAN_N24=SPCASCAN_N24 SPCASCAN_N25=SPCBSCAN_N40 SPCASCAN_N26=SPCASCAN_N26
+ SPCASCAN_N27=SPCASCAN_N24 SPCASCAN_N28=SPCASCAN_N28 SPCASCAN_N29=SPCASCAN_N29
+ test_si_i=test_si FE_OFN23_test_se_i=FE_OFN23_test_se_i
+ FE_OFN8_test_se_i=FE_OFN8_test_se_i FE_OFN103_test_se_i=FE_OFN103_test_se_i
+ FE_OFN104_test_se_i=FE_OFN104_test_se_i FE_OFN105_test_se_i=FE_OFN105_test_se_i
+ FE_OFN108_test_se_i=FE_OFN108_test_se_i FE_OFN109_test_se_i=FE_OFN109_test_se_i
+ clk_i__L3_N25=clk_i__L3_N25 clk_i__L3_N26=clk_i__L3_N26
+ clk_i__L3_N27=clk_i__L3_N27 clk_i__L3_N7=clk_i__L3_N7 clk_i__L3_N9=clk_i__L3_N9
XID InstructionDecode_test_1 $PINS clk=clk rst=n296 stall=n295
+ PCadd4[31]=PCadd4[31] PCadd4[30]=PCadd4[30] PCadd4[29]=PCadd4[29]
+ PCadd4[28]=PCadd4[28] PCadd4[27]=PCadd4[27] PCadd4[26]=PCadd4[26]
+ PCadd4[25]=PCadd4[25] PCadd4[24]=PCadd4[24] PCadd4[23]=PCadd4[23]
+ PCadd4[22]=PCadd4[22] PCadd4[21]=PCadd4[21] PCadd4[20]=PCadd4[20]
+ PCadd4[19]=PCadd4[19] PCadd4[18]=PCadd4[18] PCadd4[17]=PCadd4[17]
+ PCadd4[16]=PCadd4[16] PCadd4[15]=PCadd4[15] PCadd4[14]=PCadd4[14]
+ PCadd4[13]=PCadd4[13] PCadd4[12]=PCadd4[12] PCadd4[11]=PCadd4[11]
+ PCadd4[10]=PCadd4[10] PCadd4[9]=PCadd4[9] PCadd4[8]=PCadd4[8]
+ PCadd4[7]=PCadd4[7] PCadd4[6]=PCadd4[6] PCadd4[5]=PCadd4[5] PCadd4[4]=PCadd4[4]
+ PCadd4[3]=PCadd4[3] PCadd4[2]=PCadd4[2] PCadd4[1]=PCadd4[1] PCadd4[0]=PCadd4[0]
+ Instruction[31]=Instruction[31] Instruction[30]=Instruction[30]
+ Instruction[29]=Instruction[29] Instruction[28]=Instruction[28]
+ Instruction[27]=Instruction[27] Instruction[26]=Instruction[26]
+ Instruction[25]=n294 Instruction[24]=n293 Instruction[23]=n292
+ Instruction[22]=n291 Instruction[21]=n290 Instruction[20]=n289
+ Instruction[19]=n288 Instruction[18]=n287 Instruction[17]=n286
+ Instruction[16]=n285 Instruction[15]=Instruction[15]
+ Instruction[14]=Instruction[14] Instruction[13]=Instruction[13]
+ Instruction[12]=Instruction[12] Instruction[11]=Instruction[11]
+ Instruction[10]=Instruction[10] Instruction[9]=Instruction[9]
+ Instruction[8]=Instruction[8] Instruction[7]=Instruction[7]
+ Instruction[6]=Instruction[6] Instruction[5]=Instruction[5]
+ Instruction[4]=Instruction[4] Instruction[3]=Instruction[3]
+ Instruction[2]=Instruction[2] Instruction[1]=Instruction[1]
+ Instruction[0]=Instruction[0] PCbranched[31]=PCbranched[31]
+ PCbranched[30]=PCbranched[30] PCbranched[29]=PCbranched[29]
+ PCbranched[28]=PCbranched[28] PCbranched[27]=PCbranched[27]
+ PCbranched[26]=PCbranched[26] PCbranched[25]=PCbranched[25]
+ PCbranched[24]=PCbranched[24] PCbranched[23]=PCbranched[23]
+ PCbranched[22]=PCbranched[22] PCbranched[21]=PCbranched[21]
+ PCbranched[20]=PCbranched[20] PCbranched[19]=PCbranched[19]
+ PCbranched[18]=PCbranched[18] PCbranched[17]=PCbranched[17]
+ PCbranched[16]=PCbranched[16] PCbranched[15]=PCbranched[15]
+ PCbranched[14]=PCbranched[14] PCbranched[13]=PCbranched[13]
+ PCbranched[12]=PCbranched[12] PCbranched[11]=PCbranched[11]
+ PCbranched[10]=PCbranched[10] PCbranched[9]=PCbranched[9]
+ PCbranched[8]=PCbranched[8] PCbranched[7]=PCbranched[7]
+ PCbranched[6]=PCbranched[6] PCbranched[5]=PCbranched[5]
+ PCbranched[4]=PCbranched[4] PCbranched[3]=PCbranched[3]
+ PCbranched[2]=PCbranched[2] PCbranched[1]=PCbranched[1]
+ PCbranched[0]=PCbranched[0] Reg_W[4]=MEM_WB_RegisterRd[4]
+ Reg_W[3]=MEM_WB_RegisterRd[3] Reg_W[2]=MEM_WB_RegisterRd[2]
+ Reg_W[1]=MEM_WB_RegisterRd[1] Reg_W[0]=MEM_WB_RegisterRd[0] WriteData[31]=n259
+ WriteData[30]=n260 WriteData[29]=n257 WriteData[28]=n258 WriteData[27]=n255
+ WriteData[26]=n256 WriteData[25]=n253 WriteData[24]=n254 WriteData[23]=n251
+ WriteData[22]=n252 WriteData[21]=n249 WriteData[20]=n250 WriteData[19]=n247
+ WriteData[18]=n248 WriteData[17]=n245 WriteData[16]=n246 WriteData[15]=n244
+ WriteData[14]=n274 WriteData[13]=n272 WriteData[12]=n273 WriteData[11]=n243
+ WriteData[10]=n271 WriteData[9]=n269 WriteData[8]=n270 WriteData[7]=n267
+ WriteData[6]=n268 WriteData[5]=n265 WriteData[4]=n266 WriteData[3]=n263
+ WriteData[2]=n264 WriteData[1]=n261 WriteData[0]=n262 WB[1]=ID_EX_WBControl[1]
+ WB[0]=ID_EX_WBControl[0] MEM[2]=SYNOPSYS_UNCONNECTED__0
+ MEM[1]=ID_EX_MEMControl[1] MEM[0]=ID_EX_MEMControl[0] EX[6]=ID_EX_EXControl[6]
+ EX[5]=ID_EX_EXControl[5] EX[4]=ID_EX_EXControl[4] EX[3]=ID_EX_EXControl[3]
+ EX[2]=ID_EX_EXControl[2] EX[1]=ID_EX_EXControl[1] EX[0]=ID_EX_EXControl[0]
+ RData1[31]=ReadData1[31] RData1[30]=ReadData1[30] RData1[29]=ReadData1[29]
+ RData1[28]=ReadData1[28] RData1[27]=ReadData1[27] RData1[26]=ReadData1[26]
+ RData1[25]=ReadData1[25] RData1[24]=ReadData1[24] RData1[23]=ReadData1[23]
+ RData1[22]=ReadData1[22] RData1[21]=ReadData1[21] RData1[20]=ReadData1[20]
+ RData1[19]=ReadData1[19] RData1[18]=ReadData1[18] RData1[17]=ReadData1[17]
+ RData1[16]=ReadData1[16] RData1[15]=ReadData1[15] RData1[14]=ReadData1[14]
+ RData1[13]=ReadData1[13] RData1[12]=ReadData1[12] RData1[11]=ReadData1[11]
+ RData1[10]=ReadData1[10] RData1[9]=ReadData1[9] RData1[8]=ReadData1[8]
+ RData1[7]=ReadData1[7] RData1[6]=ReadData1[6] RData1[5]=ReadData1[5]
+ RData1[4]=ReadData1[4] RData1[3]=ReadData1[3] RData1[2]=ReadData1[2]
+ RData1[1]=ReadData1[1] RData1[0]=ReadData1[0] RData2[31]=ReadData2[31]
+ RData2[30]=ReadData2[30] RData2[29]=ReadData2[29] RData2[28]=ReadData2[28]
+ RData2[27]=ReadData2[27] RData2[26]=ReadData2[26] RData2[25]=ReadData2[25]
+ RData2[24]=ReadData2[24] RData2[23]=ReadData2[23] RData2[22]=ReadData2[22]
+ RData2[21]=ReadData2[21] RData2[20]=ReadData2[20] RData2[19]=ReadData2[19]
+ RData2[18]=ReadData2[18] RData2[17]=ReadData2[17] RData2[16]=ReadData2[16]
+ RData2[15]=ReadData2[15] RData2[14]=ReadData2[14] RData2[13]=ReadData2[13]
+ RData2[12]=ReadData2[12] RData2[11]=ReadData2[11] RData2[10]=ReadData2[10]
+ RData2[9]=ReadData2[9] RData2[8]=ReadData2[8] RData2[7]=ReadData2[7]
+ RData2[6]=ReadData2[6] RData2[5]=ReadData2[5] RData2[4]=ReadData2[4]
+ RData2[3]=ReadData2[3] RData2[2]=ReadData2[2] RData2[1]=ReadData2[1]
+ RData2[0]=ReadData2[0] next_RData1[31]=next_ReadData1[31]
+ next_RData1[30]=next_ReadData1[30] next_RData1[29]=next_ReadData1[29]
+ next_RData1[28]=next_ReadData1[28] next_RData1[27]=next_ReadData1[27]
+ next_RData1[26]=next_ReadData1[26] next_RData1[25]=next_ReadData1[25]
+ next_RData1[24]=next_ReadData1[24] next_RData1[23]=next_ReadData1[23]
+ next_RData1[22]=next_ReadData1[22] next_RData1[21]=next_ReadData1[21]
+ next_RData1[20]=next_ReadData1[20] next_RData1[19]=next_ReadData1[19]
+ next_RData1[18]=next_ReadData1[18] next_RData1[17]=next_ReadData1[17]
+ next_RData1[16]=next_ReadData1[16] next_RData1[15]=next_ReadData1[15]
+ next_RData1[14]=next_ReadData1[14] next_RData1[13]=next_ReadData1[13]
+ next_RData1[12]=next_ReadData1[12] next_RData1[11]=next_ReadData1[11]
+ next_RData1[10]=next_ReadData1[10] next_RData1[9]=next_ReadData1[9]
+ next_RData1[8]=next_ReadData1[8] next_RData1[7]=next_ReadData1[7]
+ next_RData1[6]=next_ReadData1[6] next_RData1[5]=next_ReadData1[5]
+ next_RData1[4]=next_ReadData1[4] next_RData1[3]=next_ReadData1[3]
+ next_RData1[2]=next_ReadData1[2] next_RData1[1]=next_ReadData1[1]
+ next_RData1[0]=next_ReadData1[0] Immediate_SE[31]=Immediate_SE[31]
+ Immediate_SE[30]=Immediate_SE[30] Immediate_SE[29]=Immediate_SE[29]
+ Immediate_SE[28]=Immediate_SE[28] Immediate_SE[27]=Immediate_SE[27]
+ Immediate_SE[26]=Immediate_SE[26] Immediate_SE[25]=Immediate_SE[25]
+ Immediate_SE[24]=Immediate_SE[24] Immediate_SE[23]=Immediate_SE[23]
+ Immediate_SE[22]=Immediate_SE[22] Immediate_SE[21]=Immediate_SE[21]
+ Immediate_SE[20]=Immediate_SE[20] Immediate_SE[19]=Immediate_SE[19]
+ Immediate_SE[18]=Immediate_SE[18] Immediate_SE[17]=Immediate_SE[17]
+ Immediate_SE[16]=Immediate_SE[16] Immediate_SE[15]=Immediate_SE[15]
+ Immediate_SE[14]=Immediate_SE[14] Immediate_SE[13]=Immediate_SE[13]
+ Immediate_SE[12]=Immediate_SE[12] Immediate_SE[11]=Immediate_SE[11]
+ Immediate_SE[10]=Immediate_SE[10] Immediate_SE[9]=Immediate_SE[9]
+ Immediate_SE[8]=Immediate_SE[8] Immediate_SE[7]=Immediate_SE[7]
+ Immediate_SE[6]=Immediate_SE[6] Immediate_SE[5]=Immediate_SE[5]
+ Immediate_SE[4]=Immediate_SE[4] Immediate_SE[3]=Immediate_SE[3]
+ Immediate_SE[2]=Immediate_SE[2] Immediate_SE[1]=Immediate_SE[1]
+ Immediate_SE[0]=Immediate_SE[0] RegisterRd[4]=ID_EX_RegisterRd[4]
+ RegisterRd[3]=ID_EX_RegisterRd[3] RegisterRd[2]=ID_EX_RegisterRd[2]
+ RegisterRd[1]=ID_EX_RegisterRd[1] RegisterRd[0]=ID_EX_RegisterRd[0]
+ RegisterRs[4]=ID_EX_RegisterRs[4] RegisterRs[3]=ID_EX_RegisterRs[3]
+ RegisterRs[2]=ID_EX_RegisterRs[2] RegisterRs[1]=ID_EX_RegisterRs[1]
+ RegisterRs[0]=ID_EX_RegisterRs[0] RegisterRt[4]=ID_EX_RegisterRt[4]
+ RegisterRt[3]=ID_EX_RegisterRt[3] RegisterRt[2]=ID_EX_RegisterRt[2]
+ RegisterRt[1]=ID_EX_RegisterRt[1] RegisterRt[0]=ID_EX_RegisterRt[0]
+ MEM_RegWrite=MEM_WB_WBControl[1] RegDst=n346 Jump=Jump Branch=Branch
+ MemRead=n57 MemtoReg=n57 MemWrite=n56 ALUOp[2]=n55 ALUOp[1]=n241
+ ALUOp[0]=ALUOp[0] ALUSrc=ALUSrc RegWrite=n54 Bubble=N182
+ PCBuffer_valid=PCBuffer_valid EX_RegWriteData[31]=next_ALUresult[31]
+ EX_RegWriteData[30]=next_ALUresult[30] EX_RegWriteData[29]=next_ALUresult[29]
+ EX_RegWriteData[28]=next_ALUresult[28] EX_RegWriteData[27]=next_ALUresult[27]
+ EX_RegWriteData[26]=next_ALUresult[26] EX_RegWriteData[25]=next_ALUresult[25]
+ EX_RegWriteData[24]=next_ALUresult[24] EX_RegWriteData[23]=next_ALUresult[23]
+ EX_RegWriteData[22]=next_ALUresult[22] EX_RegWriteData[21]=next_ALUresult[21]
+ EX_RegWriteData[20]=next_ALUresult[20] EX_RegWriteData[19]=next_ALUresult[19]
+ EX_RegWriteData[18]=next_ALUresult[18] EX_RegWriteData[17]=next_ALUresult[17]
+ EX_RegWriteData[16]=next_ALUresult[16] EX_RegWriteData[15]=next_ALUresult[15]
+ EX_RegWriteData[14]=next_ALUresult[14] EX_RegWriteData[13]=next_ALUresult[13]
+ EX_RegWriteData[12]=next_ALUresult[12] EX_RegWriteData[11]=next_ALUresult[11]
+ EX_RegWriteData[10]=next_ALUresult[10] EX_RegWriteData[9]=next_ALUresult[9]
+ EX_RegWriteData[8]=next_ALUresult[8] EX_RegWriteData[7]=next_ALUresult[7]
+ EX_RegWriteData[6]=next_ALUresult[6] EX_RegWriteData[5]=next_ALUresult[5]
+ EX_RegWriteData[4]=next_ALUresult[4] EX_RegWriteData[3]=next_ALUresult[3]
+ EX_RegWriteData[2]=next_ALUresult[2] EX_RegWriteData[1]=next_ALUresult[1]
+ EX_RegWriteData[0]=next_ALUresult[0] MEM_RegWriteData[31]=DCACHE_addr[31]
+ MEM_RegWriteData[30]=DCACHE_addr[30] MEM_RegWriteData[29]=DCACHE_addr[29]
+ MEM_RegWriteData[28]=DCACHE_addr[28] MEM_RegWriteData[27]=DCACHE_addr[27]
+ MEM_RegWriteData[26]=DCACHE_addr[26] MEM_RegWriteData[25]=DCACHE_addr[25]
+ MEM_RegWriteData[24]=DCACHE_addr[24] MEM_RegWriteData[23]=DCACHE_addr[23]
+ MEM_RegWriteData[22]=DCACHE_addr[22] MEM_RegWriteData[21]=DCACHE_addr[21]
+ MEM_RegWriteData[20]=DCACHE_addr[20] MEM_RegWriteData[19]=DCACHE_addr[19]
+ MEM_RegWriteData[18]=DCACHE_addr[18] MEM_RegWriteData[17]=DCACHE_addr[17]
+ MEM_RegWriteData[16]=DCACHE_addr[16] MEM_RegWriteData[15]=DCACHE_addr[15]
+ MEM_RegWriteData[14]=DCACHE_addr[14] MEM_RegWriteData[13]=DCACHE_addr[13]
+ MEM_RegWriteData[12]=DCACHE_addr[12] MEM_RegWriteData[11]=DCACHE_addr[11]
+ MEM_RegWriteData[10]=DCACHE_addr[10] MEM_RegWriteData[9]=DCACHE_addr[9]
+ MEM_RegWriteData[8]=DCACHE_addr[8] MEM_RegWriteData[7]=DCACHE_addr[7]
+ MEM_RegWriteData[6]=DCACHE_addr[6] MEM_RegWriteData[5]=DCACHE_addr[5]
+ MEM_RegWriteData[4]=DCACHE_addr[4] MEM_RegWriteData[3]=DCACHE_addr[3]
+ MEM_RegWriteData[2]=DCACHE_addr[2] MEM_RegWriteData[1]=DCACHE_addr[1]
+ MEM_RegWriteData[0]=DCACHE_addr[0] BrForwardA[1]=BrForwardA[1]
+ BrForwardA[0]=BrForwardA[0] BrForwardB[1]=BrForwardB[1]
+ BrForwardB[0]=BrForwardB[0] PredictMiss=PredictMiss BranchTaken=BranchTaken
+ test_si2=n4 test_si1=test_si test_so2=n3 test_so1=n6 test_se=test_se
+ SPCASCAN_N1=SPCASCAN_N1 FE_PT1_ICACHE_addr_i_8_=ICACHE_addr[8]
+ SPCASCAN_N2=SPCASCAN_N2 FE_PT1_ICACHE_addr_i_9_=SPCASCAN_N3
+ SPCASCAN_N3=SPCASCAN_N3 FE_PT1_ICACHE_addr_i_18_=ICACHE_addr[18]
+ SPCASCAN_N4=SPCASCAN_N4 FE_PT1_ICACHE_addr_i_31_=ICACHE_addr[31]
+ SPCASCAN_N5=SPCASCAN_N5 SPCASCAN_N6=SPCASCAN_N6 SPCASCAN_N7=SPCASCAN_N7
+ SPCASCAN_N8=SPCASCAN_N8 SPCASCAN_N12=SPCASCAN_N12
+ FE_PT1_ICACHE_addr_i_26_=ICACHE_addr[26] SPCASCAN_N13=SPCASCAN_N13
+ SPCASCAN_N14=SPCASCAN_N14 SPCASCAN_N15=SPCASCAN_N15 SPCASCAN_N16=SPCASCAN_N16
+ SPCASCAN_N17=SPCASCAN_N17 SPCASCAN_N18=SPCASCAN_N19 SPCASCAN_N19=SPCASCAN_N19
+ SPCASCAN_N20=SPCASCAN_N18 SPCASCAN_N21=SPCASCAN_N21 SPCASCAN_N22=SPCASCAN_N22
+ FE_PT1_ICACHE_addr_i_30_=ICACHE_addr[30] SPCASCAN_N23=SPCASCAN_N23
+ SPCASCAN_N24=ICACHE_addr[7] SPCASCAN_N25=SPCASCAN_N25
+ FE_PT1_ICACHE_addr_i_3_=ICACHE_addr[3] SPCASCAN_N26=SPCASCAN_N26
+ FE_PT1_ICACHE_addr_i_7_=ICACHE_addr[7] SPCASCAN_N27=SPCASCAN_N27
+ FE_PT1_ICACHE_addr_i_6_=ICACHE_addr[6] SPCASCAN_N28=SPCASCAN_N28
+ FE_PT1_ICACHE_addr_i_5_=ICACHE_addr[5] SPCASCAN_N29=SPCASCAN_N29
+ SPCASCAN_N30=SPCASCAN_N30 SPCASCAN_N31=SPCASCAN_N31 SPCASCAN_N32=SPCASCAN_N32
+ SPCASCAN_N33=SPCASCAN_N33 SPCASCAN_N34=SPCASCAN_N34 SPCASCAN_N35=SPCASCAN_N35
+ SPCASCAN_N36=SPCASCAN_N36 SPCASCAN_N37=SPCASCAN_N37
+ FE_PT1_ICACHE_addr_i_17_=ICACHE_addr[17] FE_OFN0_test_se_i=FE_OFN0_test_se_i
+ FE_OFN13_test_se_i=FE_OFN15_test_se_i FE_OFN14_test_se_i=FE_OFN14_test_se_i
+ FE_OFN15_test_se_i=FE_OFN15_test_se_i FE_OFN18_test_se_i=FE_OFN18_test_se_i
+ FE_OFN1_test_se_i=FE_OFN1_test_se_i FE_OFN20_test_se_i=FE_OFN20_test_se_i
+ FE_OFN21_test_se_i=FE_OFN21_test_se_i FE_OFN23_test_se_i=FE_OFN104_test_se_i
+ FE_OFN4_test_se_i=FE_OFN4_test_se_i FE_OFN5_test_se_i=FE_OFN51_test_se_i
+ FE_OFN7_test_se_i=FE_OFN7_test_se_i FE_OFN8_test_se_i=FE_OFN8_test_se_i
+ FE_PT1_n337=n337 FE_PT1_n336=n336 SPCBSCAN_N38=SPCBSCAN_N38
+ SPCBSCAN_N39=SPCBSCAN_N39 SPCBSCAN_N40=SPCBSCAN_N40 SPCBSCAN_N41=SPCBSCAN_N41
+ SPCBSCAN_N42=SPCBSCAN_N42 FE_OFN53_test_se_i=FE_OFN53_test_se_i
+ FE_OFN54_test_se_i=FE_OFN54_test_se_i FE_OFN74_test_se_i=FE_OFN74_test_se_i
+ FE_OFN75_test_se_i=FE_OFN75_test_se_i FE_OFN93_test_se_i=FE_OFN93_test_se_i
+ FE_OFN94_test_se_i=FE_OFN94_test_se_i FE_OFN96_test_se_i=FE_OFN96_test_se_i
+ FE_OFN97_test_se_i=FE_OFN97_test_se_i FE_OFN100_test_se_i=FE_OFN100_test_se_i
+ FE_OFN101_test_se_i=FE_OFN101_test_se_i FE_OFN99_test_se_i=FE_OFN99_test_se_i
+ FE_OFN102_test_se_i=FE_OFN102_test_se_i FE_OFN105_test_se_i=FE_OFN105_test_se_i
+ FE_OFN106_test_se_i=FE_OFN106_test_se_i FE_OFN108_test_se_i=FE_OFN108_test_se_i
+ FE_OFN109_test_se_i=FE_OFN109_test_se_i FE_OFN110_test_se_i=FE_OFN110_test_se_i
+ FE_OFN113_test_se_i=FE_OFN113_test_se_i FE_OFN114_test_se_i=FE_OFN114_test_se_i
+ FE_OFN116_test_se_i=FE_OFN116_test_se_i clk_i__L3_N1=clk_i__L3_N1
+ clk_i__L3_N10=clk_i__L3_N10 clk_i__L3_N11=clk_i__L3_N11
+ clk_i__L3_N12=clk_i__L3_N12 clk_i__L3_N13=clk_i__L3_N13
+ clk_i__L3_N14=clk_i__L3_N14 clk_i__L3_N15=clk_i__L3_N15
+ clk_i__L3_N16=clk_i__L3_N16 clk_i__L3_N17=clk_i__L3_N17
+ clk_i__L3_N18=clk_i__L3_N18 clk_i__L3_N19=clk_i__L3_N19
+ clk_i__L3_N2=clk_i__L3_N2 clk_i__L3_N20=clk_i__L3_N20
+ clk_i__L3_N21=clk_i__L3_N21 clk_i__L3_N22=clk_i__L3_N22
+ clk_i__L3_N23=clk_i__L3_N23 clk_i__L3_N24=clk_i__L3_N24
+ clk_i__L3_N25=clk_i__L3_N25 clk_i__L3_N26=clk_i__L3_N26
+ clk_i__L3_N27=clk_i__L3_N27 clk_i__L3_N3=clk_i__L3_N3 clk_i__L3_N4=clk_i__L3_N4
+ clk_i__L3_N5=clk_i__L3_N5 clk_i__L3_N6=clk_i__L3_N6 clk_i__L3_N7=clk_i__L3_N7
+ clk_i__L3_N8=clk_i__L3_N8 clk_i__L3_N9=clk_i__L3_N9
XEX Execution_test_1 $PINS clk=clk_i__L3_N10 rst=n296 stall=n295
+ ID_WB[1]=ID_EX_WBControl[1] ID_WB[0]=ID_EX_WBControl[0] ID_MEM[2]=VSS
+ ID_MEM[1]=ID_EX_MEMControl[1] ID_MEM[0]=ID_EX_MEMControl[0]
+ ID_EX[6]=ID_EX_EXControl[6] ID_EX[5]=ID_EX_EXControl[5]
+ ID_EX[4]=ID_EX_EXControl[4] ID_EX[3]=ID_EX_EXControl[3]
+ ID_EX[2]=ID_EX_EXControl[2] ID_EX[1]=ID_EX_EXControl[1]
+ ID_EX[0]=ID_EX_EXControl[0] RData1[31]=ReadData1[31] RData1[30]=ReadData1[30]
+ RData1[29]=ReadData1[29] RData1[28]=ReadData1[28] RData1[27]=ReadData1[27]
+ RData1[26]=ReadData1[26] RData1[25]=ReadData1[25] RData1[24]=ReadData1[24]
+ RData1[23]=ReadData1[23] RData1[22]=ReadData1[22] RData1[21]=ReadData1[21]
+ RData1[20]=ReadData1[20] RData1[19]=ReadData1[19] RData1[18]=ReadData1[18]
+ RData1[17]=ReadData1[17] RData1[16]=ReadData1[16] RData1[15]=ReadData1[15]
+ RData1[14]=ReadData1[14] RData1[13]=ReadData1[13] RData1[12]=ReadData1[12]
+ RData1[11]=ReadData1[11] RData1[10]=ReadData1[10] RData1[9]=ReadData1[9]
+ RData1[8]=ReadData1[8] RData1[7]=ReadData1[7] RData1[6]=ReadData1[6]
+ RData1[5]=ReadData1[5] RData1[4]=ReadData1[4] RData1[3]=ReadData1[3]
+ RData1[2]=ReadData1[2] RData1[1]=ReadData1[1] RData1[0]=ReadData1[0]
+ RData2[31]=ReadData2[31] RData2[30]=ReadData2[30] RData2[29]=ReadData2[29]
+ RData2[28]=ReadData2[28] RData2[27]=ReadData2[27] RData2[26]=ReadData2[26]
+ RData2[25]=ReadData2[25] RData2[24]=ReadData2[24] RData2[23]=ReadData2[23]
+ RData2[22]=ReadData2[22] RData2[21]=ReadData2[21] RData2[20]=ReadData2[20]
+ RData2[19]=ReadData2[19] RData2[18]=ReadData2[18] RData2[17]=ReadData2[17]
+ RData2[16]=ReadData2[16] RData2[15]=ReadData2[15] RData2[14]=ReadData2[14]
+ RData2[13]=ReadData2[13] RData2[12]=ReadData2[12] RData2[11]=ReadData2[11]
+ RData2[10]=ReadData2[10] RData2[9]=ReadData2[9] RData2[8]=ReadData2[8]
+ RData2[7]=ReadData2[7] RData2[6]=ReadData2[6] RData2[5]=ReadData2[5]
+ RData2[4]=ReadData2[4] RData2[3]=ReadData2[3] RData2[2]=ReadData2[2]
+ RData2[1]=ReadData2[1] RData2[0]=ReadData2[0] Immediate_SE[31]=Immediate_SE[31]
+ Immediate_SE[30]=Immediate_SE[30] Immediate_SE[29]=Immediate_SE[29]
+ Immediate_SE[28]=Immediate_SE[28] Immediate_SE[27]=Immediate_SE[27]
+ Immediate_SE[26]=Immediate_SE[26] Immediate_SE[25]=Immediate_SE[25]
+ Immediate_SE[24]=Immediate_SE[24] Immediate_SE[23]=Immediate_SE[23]
+ Immediate_SE[22]=Immediate_SE[22] Immediate_SE[21]=Immediate_SE[21]
+ Immediate_SE[20]=Immediate_SE[20] Immediate_SE[19]=Immediate_SE[19]
+ Immediate_SE[18]=Immediate_SE[18] Immediate_SE[17]=Immediate_SE[17]
+ Immediate_SE[16]=Immediate_SE[16] Immediate_SE[15]=Immediate_SE[15]
+ Immediate_SE[14]=Immediate_SE[14] Immediate_SE[13]=Immediate_SE[13]
+ Immediate_SE[12]=Immediate_SE[12] Immediate_SE[11]=Immediate_SE[11]
+ Immediate_SE[10]=n284 Immediate_SE[9]=n283 Immediate_SE[8]=n282
+ Immediate_SE[7]=n281 Immediate_SE[6]=n280 Immediate_SE[5]=Immediate_SE[5]
+ Immediate_SE[4]=Immediate_SE[4] Immediate_SE[3]=Immediate_SE[3]
+ Immediate_SE[2]=Immediate_SE[2] Immediate_SE[1]=Immediate_SE[1]
+ Immediate_SE[0]=Immediate_SE[0] ID_RegisterRt[4]=ID_EX_RegisterRt[4]
+ ID_RegisterRt[3]=ID_EX_RegisterRt[3] ID_RegisterRt[2]=ID_EX_RegisterRt[2]
+ ID_RegisterRt[1]=ID_EX_RegisterRt[1] ID_RegisterRt[0]=ID_EX_RegisterRt[0]
+ ID_RegisterRd[4]=ID_EX_RegisterRd[4] ID_RegisterRd[3]=ID_EX_RegisterRd[3]
+ ID_RegisterRd[2]=ID_EX_RegisterRd[2] ID_RegisterRd[1]=ID_EX_RegisterRd[1]
+ ID_RegisterRd[0]=ID_EX_RegisterRd[0] WB[1]=EX_MEM_WBControl[1]
+ WB[0]=EX_MEM_WBControl[0] MEM[2]=EX_MEM_MEMControl[2]
+ MEM[1]=EX_MEM_MEMControl[1] MEM[0]=EX_MEM_MEMControl[0]
+ next_ALUresult[31]=next_ALUresult[31] next_ALUresult[30]=next_ALUresult[30]
+ next_ALUresult[29]=next_ALUresult[29] next_ALUresult[28]=next_ALUresult[28]
+ next_ALUresult[27]=next_ALUresult[27] next_ALUresult[26]=next_ALUresult[26]
+ next_ALUresult[25]=next_ALUresult[25] next_ALUresult[24]=next_ALUresult[24]
+ next_ALUresult[23]=next_ALUresult[23] next_ALUresult[22]=next_ALUresult[22]
+ next_ALUresult[21]=next_ALUresult[21] next_ALUresult[20]=next_ALUresult[20]
+ next_ALUresult[19]=next_ALUresult[19] next_ALUresult[18]=next_ALUresult[18]
+ next_ALUresult[17]=next_ALUresult[17] next_ALUresult[16]=next_ALUresult[16]
+ next_ALUresult[15]=next_ALUresult[15] next_ALUresult[14]=next_ALUresult[14]
+ next_ALUresult[13]=next_ALUresult[13] next_ALUresult[12]=next_ALUresult[12]
+ next_ALUresult[11]=next_ALUresult[11] next_ALUresult[10]=next_ALUresult[10]
+ next_ALUresult[9]=next_ALUresult[9] next_ALUresult[8]=next_ALUresult[8]
+ next_ALUresult[7]=next_ALUresult[7] next_ALUresult[6]=next_ALUresult[6]
+ next_ALUresult[5]=next_ALUresult[5] next_ALUresult[4]=next_ALUresult[4]
+ next_ALUresult[3]=next_ALUresult[3] next_ALUresult[2]=next_ALUresult[2]
+ next_ALUresult[1]=next_ALUresult[1] next_ALUresult[0]=next_ALUresult[0]
+ ALUresult[31]=DCACHE_addr[31] ALUresult[30]=DCACHE_addr[30]
+ ALUresult[29]=DCACHE_addr[29] ALUresult[28]=DCACHE_addr[28]
+ ALUresult[27]=DCACHE_addr[27] ALUresult[26]=DCACHE_addr[26]
+ ALUresult[25]=DCACHE_addr[25] ALUresult[24]=DCACHE_addr[24]
+ ALUresult[23]=DCACHE_addr[23] ALUresult[22]=DCACHE_addr[22]
+ ALUresult[21]=DCACHE_addr[21] ALUresult[20]=DCACHE_addr[20]
+ ALUresult[19]=DCACHE_addr[19] ALUresult[18]=DCACHE_addr[18]
+ ALUresult[17]=DCACHE_addr[17] ALUresult[16]=DCACHE_addr[16]
+ ALUresult[15]=DCACHE_addr[15] ALUresult[14]=DCACHE_addr[14]
+ ALUresult[13]=DCACHE_addr[13] ALUresult[12]=DCACHE_addr[12]
+ ALUresult[11]=DCACHE_addr[11] ALUresult[10]=DCACHE_addr[10]
+ ALUresult[9]=DCACHE_addr[9] ALUresult[8]=DCACHE_addr[8]
+ ALUresult[7]=DCACHE_addr[7] ALUresult[6]=DCACHE_addr[6]
+ ALUresult[5]=DCACHE_addr[5] ALUresult[4]=DCACHE_addr[4]
+ ALUresult[3]=DCACHE_addr[3] ALUresult[2]=DCACHE_addr[2]
+ ALUresult[1]=DCACHE_addr[1] ALUresult[0]=DCACHE_addr[0]
+ MEMWriteData[31]=DCACHE_wdata[31] MEMWriteData[30]=DCACHE_wdata[30]
+ MEMWriteData[29]=DCACHE_wdata[29] MEMWriteData[28]=DCACHE_wdata[28]
+ MEMWriteData[27]=DCACHE_wdata[27] MEMWriteData[26]=DCACHE_wdata[26]
+ MEMWriteData[25]=DCACHE_wdata[25] MEMWriteData[24]=DCACHE_wdata[24]
+ MEMWriteData[23]=DCACHE_wdata[23] MEMWriteData[22]=DCACHE_wdata[22]
+ MEMWriteData[21]=DCACHE_wdata[21] MEMWriteData[20]=DCACHE_wdata[20]
+ MEMWriteData[19]=DCACHE_wdata[19] MEMWriteData[18]=DCACHE_wdata[18]
+ MEMWriteData[17]=DCACHE_wdata[17] MEMWriteData[16]=DCACHE_wdata[16]
+ MEMWriteData[15]=DCACHE_wdata[15] MEMWriteData[14]=DCACHE_wdata[14]
+ MEMWriteData[13]=DCACHE_wdata[13] MEMWriteData[12]=DCACHE_wdata[12]
+ MEMWriteData[11]=DCACHE_wdata[11] MEMWriteData[10]=DCACHE_wdata[10]
+ MEMWriteData[9]=DCACHE_wdata[9] MEMWriteData[8]=DCACHE_wdata[8]
+ MEMWriteData[7]=DCACHE_wdata[7] MEMWriteData[6]=DCACHE_wdata[6]
+ MEMWriteData[5]=DCACHE_wdata[5] MEMWriteData[4]=DCACHE_wdata[4]
+ MEMWriteData[3]=DCACHE_wdata[3] MEMWriteData[2]=DCACHE_wdata[2]
+ MEMWriteData[1]=DCACHE_wdata[1] MEMWriteData[0]=DCACHE_wdata[0]
+ RegisterRd[4]=EX_MEM_RegisterRd[4] RegisterRd[3]=EX_MEM_RegisterRd[3]
+ RegisterRd[2]=EX_MEM_RegisterRd[2] RegisterRd[1]=EX_MEM_RegisterRd[1]
+ RegisterRd[0]=EX_MEM_RegisterRd[0] WBData[31]=n259 WBData[30]=n260
+ WBData[29]=n257 WBData[28]=n258 WBData[27]=n255 WBData[26]=n256 WBData[25]=n253
+ WBData[24]=n254 WBData[23]=n251 WBData[22]=n252 WBData[21]=n249 WBData[20]=n250
+ WBData[19]=n247 WBData[18]=n248 WBData[17]=n245 WBData[16]=n246 WBData[15]=n244
+ WBData[14]=n274 WBData[13]=n272 WBData[12]=n273 WBData[11]=n243 WBData[10]=n271
+ WBData[9]=n269 WBData[8]=n270 WBData[7]=n267 WBData[6]=n268 WBData[5]=n265
+ WBData[4]=n266 WBData[3]=n263 WBData[2]=n264 WBData[1]=n261 WBData[0]=n262
+ ForwardA[1]=ForwardA[1] ForwardA[0]=ForwardA[0] ForwardB[1]=ForwardB[1]
+ ForwardB[0]=ForwardB[0] test_si=n5 test_so=n4 test_se=FE_OFN14_test_se_i
+ SPCASCAN_N0=SPCASCAN_N0 FE_PT1_ICACHE_addr_i_21_=ICACHE_addr[21]
+ SPCASCAN_N8=SPCASCAN_N8 FE_PT1_ICACHE_addr_i_22_=ICACHE_addr[22]
+ SPCASCAN_N9=SPCASCAN_N9 SPCASCAN_N10=SPCASCAN_N10 SPCASCAN_N11=SPCASCAN_N11
+ SPCASCAN_N12=SPCASCAN_N12 SPCASCAN_N16=SPCASCAN_N16 SPCASCAN_N17=SPCASCAN_N17
+ SPCASCAN_N21=SPCASCAN_N21 SPCASCAN_N22=SPCASCAN_N22
+ FE_OFN15_test_se_i=FE_OFN15_test_se_i FE_OFN21_test_se_i=FE_OFN101_test_se_i
+ FE_OFN8_test_se_i=FE_OFN109_test_se_i SPCBSCAN_N39=SPCBSCAN_N39
+ FE_OFN93_test_se_i=FE_OFN93_test_se_i FE_OFN94_test_se_i=FE_OFN94_test_se_i
+ FE_OFN96_test_se_i=FE_OFN96_test_se_i FE_OFN97_test_se_i=FE_OFN97_test_se_i
+ clk_i__L3_N11=clk_i__L3_N11 clk_i__L3_N2=clk_i__L3_N2 clk_i__L3_N9=clk_i__L3_N9
XDMEM DataMemory_test_1 $PINS clk=clk_i__L3_N16 rst=n296 stall=n295
+ EX_WB[1]=EX_MEM_WBControl[1] EX_WB[0]=EX_MEM_WBControl[0]
+ EX_MEM[2]=EX_MEM_MEMControl[2] EX_MEM[1]=EX_MEM_MEMControl[1]
+ EX_MEM[0]=EX_MEM_MEMControl[0] EX_ALUresult[31]=DCACHE_addr[31]
+ EX_ALUresult[30]=DCACHE_addr[30] EX_ALUresult[29]=DCACHE_addr[29]
+ EX_ALUresult[28]=DCACHE_addr[28] EX_ALUresult[27]=DCACHE_addr[27]
+ EX_ALUresult[26]=DCACHE_addr[26] EX_ALUresult[25]=DCACHE_addr[25]
+ EX_ALUresult[24]=DCACHE_addr[24] EX_ALUresult[23]=DCACHE_addr[23]
+ EX_ALUresult[22]=DCACHE_addr[22] EX_ALUresult[21]=DCACHE_addr[21]
+ EX_ALUresult[20]=DCACHE_addr[20] EX_ALUresult[19]=DCACHE_addr[19]
+ EX_ALUresult[18]=DCACHE_addr[18] EX_ALUresult[17]=DCACHE_addr[17]
+ EX_ALUresult[16]=DCACHE_addr[16] EX_ALUresult[15]=DCACHE_addr[15]
+ EX_ALUresult[14]=DCACHE_addr[14] EX_ALUresult[13]=DCACHE_addr[13]
+ EX_ALUresult[12]=DCACHE_addr[12] EX_ALUresult[11]=DCACHE_addr[11]
+ EX_ALUresult[10]=DCACHE_addr[10] EX_ALUresult[9]=DCACHE_addr[9]
+ EX_ALUresult[8]=DCACHE_addr[8] EX_ALUresult[7]=DCACHE_addr[7]
+ EX_ALUresult[6]=DCACHE_addr[6] EX_ALUresult[5]=DCACHE_addr[5]
+ EX_ALUresult[4]=DCACHE_addr[4] EX_ALUresult[3]=DCACHE_addr[3]
+ EX_ALUresult[2]=DCACHE_addr[2] EX_ALUresult[1]=DCACHE_addr[1]
+ EX_ALUresult[0]=DCACHE_addr[0] EX_RegisterRd[4]=EX_MEM_RegisterRd[4]
+ EX_RegisterRd[3]=EX_MEM_RegisterRd[3] EX_RegisterRd[2]=EX_MEM_RegisterRd[2]
+ EX_RegisterRd[1]=EX_MEM_RegisterRd[1] EX_RegisterRd[0]=EX_MEM_RegisterRd[0]
+ MEMWriteData[31]=DCACHE_wdata[31] MEMWriteData[30]=DCACHE_wdata[30]
+ MEMWriteData[29]=DCACHE_wdata[29] MEMWriteData[28]=DCACHE_wdata[28]
+ MEMWriteData[27]=DCACHE_wdata[27] MEMWriteData[26]=DCACHE_wdata[26]
+ MEMWriteData[25]=DCACHE_wdata[25] MEMWriteData[24]=DCACHE_wdata[24]
+ MEMWriteData[23]=DCACHE_wdata[23] MEMWriteData[22]=DCACHE_wdata[22]
+ MEMWriteData[21]=DCACHE_wdata[21] MEMWriteData[20]=DCACHE_wdata[20]
+ MEMWriteData[19]=DCACHE_wdata[19] MEMWriteData[18]=DCACHE_wdata[18]
+ MEMWriteData[17]=DCACHE_wdata[17] MEMWriteData[16]=DCACHE_wdata[16]
+ MEMWriteData[15]=DCACHE_wdata[15] MEMWriteData[14]=DCACHE_wdata[14]
+ MEMWriteData[13]=DCACHE_wdata[13] MEMWriteData[12]=DCACHE_wdata[12]
+ MEMWriteData[11]=DCACHE_wdata[11] MEMWriteData[10]=DCACHE_wdata[10]
+ MEMWriteData[9]=DCACHE_wdata[9] MEMWriteData[8]=DCACHE_wdata[8]
+ MEMWriteData[7]=DCACHE_wdata[7] MEMWriteData[6]=DCACHE_wdata[6]
+ MEMWriteData[5]=DCACHE_wdata[5] MEMWriteData[4]=DCACHE_wdata[4]
+ MEMWriteData[3]=DCACHE_wdata[3] MEMWriteData[2]=DCACHE_wdata[2]
+ MEMWriteData[1]=DCACHE_wdata[1] MEMWriteData[0]=DCACHE_wdata[0]
+ WB[1]=MEM_WB_WBControl[1] WB[0]=MEM_WB_WBControl[0]
+ MemoryData[31]=MemoryData[31] MemoryData[30]=MemoryData[30]
+ MemoryData[29]=MemoryData[29] MemoryData[28]=MemoryData[28]
+ MemoryData[27]=MemoryData[27] MemoryData[26]=MemoryData[26]
+ MemoryData[25]=MemoryData[25] MemoryData[24]=MemoryData[24]
+ MemoryData[23]=MemoryData[23] MemoryData[22]=MemoryData[22]
+ MemoryData[21]=MemoryData[21] MemoryData[20]=MemoryData[20]
+ MemoryData[19]=MemoryData[19] MemoryData[18]=MemoryData[18]
+ MemoryData[17]=MemoryData[17] MemoryData[16]=MemoryData[16]
+ MemoryData[15]=MemoryData[15] MemoryData[14]=MemoryData[14]
+ MemoryData[13]=MemoryData[13] MemoryData[12]=MemoryData[12]
+ MemoryData[11]=MemoryData[11] MemoryData[10]=MemoryData[10]
+ MemoryData[9]=MemoryData[9] MemoryData[8]=MemoryData[8]
+ MemoryData[7]=MemoryData[7] MemoryData[6]=MemoryData[6]
+ MemoryData[5]=MemoryData[5] MemoryData[4]=MemoryData[4]
+ MemoryData[3]=MemoryData[3] MemoryData[2]=MemoryData[2]
+ MemoryData[1]=MemoryData[1] MemoryData[0]=MemoryData[0]
+ ALUresult[31]=Buf_ALUresult[31] ALUresult[30]=Buf_ALUresult[30]
+ ALUresult[29]=Buf_ALUresult[29] ALUresult[28]=Buf_ALUresult[28]
+ ALUresult[27]=Buf_ALUresult[27] ALUresult[26]=Buf_ALUresult[26]
+ ALUresult[25]=Buf_ALUresult[25] ALUresult[24]=Buf_ALUresult[24]
+ ALUresult[23]=Buf_ALUresult[23] ALUresult[22]=Buf_ALUresult[22]
+ ALUresult[21]=Buf_ALUresult[21] ALUresult[20]=Buf_ALUresult[20]
+ ALUresult[19]=Buf_ALUresult[19] ALUresult[18]=Buf_ALUresult[18]
+ ALUresult[17]=Buf_ALUresult[17] ALUresult[16]=Buf_ALUresult[16]
+ ALUresult[15]=Buf_ALUresult[15] ALUresult[14]=Buf_ALUresult[14]
+ ALUresult[13]=Buf_ALUresult[13] ALUresult[12]=Buf_ALUresult[12]
+ ALUresult[11]=Buf_ALUresult[11] ALUresult[10]=Buf_ALUresult[10]
+ ALUresult[9]=Buf_ALUresult[9] ALUresult[8]=Buf_ALUresult[8]
+ ALUresult[7]=Buf_ALUresult[7] ALUresult[6]=Buf_ALUresult[6]
+ ALUresult[5]=Buf_ALUresult[5] ALUresult[4]=Buf_ALUresult[4]
+ ALUresult[3]=Buf_ALUresult[3] ALUresult[2]=Buf_ALUresult[2]
+ ALUresult[1]=Buf_ALUresult[1] ALUresult[0]=Buf_ALUresult[0]
+ RegisterRd[4]=MEM_WB_RegisterRd[4] RegisterRd[3]=MEM_WB_RegisterRd[3]
+ RegisterRd[2]=MEM_WB_RegisterRd[2] RegisterRd[1]=MEM_WB_RegisterRd[1]
+ RegisterRd[0]=MEM_WB_RegisterRd[0] read_MemoryData[31]=DCACHE_rdata[31]
+ read_MemoryData[30]=DCACHE_rdata[30] read_MemoryData[29]=DCACHE_rdata[29]
+ read_MemoryData[28]=DCACHE_rdata[28] read_MemoryData[27]=DCACHE_rdata[27]
+ read_MemoryData[26]=DCACHE_rdata[26] read_MemoryData[25]=DCACHE_rdata[25]
+ read_MemoryData[24]=DCACHE_rdata[24] read_MemoryData[23]=DCACHE_rdata[23]
+ read_MemoryData[22]=DCACHE_rdata[22] read_MemoryData[21]=DCACHE_rdata[21]
+ read_MemoryData[20]=DCACHE_rdata[20] read_MemoryData[19]=DCACHE_rdata[19]
+ read_MemoryData[18]=DCACHE_rdata[18] read_MemoryData[17]=DCACHE_rdata[17]
+ read_MemoryData[16]=DCACHE_rdata[16] read_MemoryData[15]=DCACHE_rdata[15]
+ read_MemoryData[14]=DCACHE_rdata[14] read_MemoryData[13]=DCACHE_rdata[13]
+ read_MemoryData[12]=DCACHE_rdata[12] read_MemoryData[11]=DCACHE_rdata[11]
+ read_MemoryData[10]=DCACHE_rdata[10] read_MemoryData[9]=DCACHE_rdata[9]
+ read_MemoryData[8]=DCACHE_rdata[8] read_MemoryData[7]=DCACHE_rdata[7]
+ read_MemoryData[6]=DCACHE_rdata[6] read_MemoryData[5]=DCACHE_rdata[5]
+ read_MemoryData[4]=DCACHE_rdata[4] read_MemoryData[3]=DCACHE_rdata[3]
+ read_MemoryData[2]=DCACHE_rdata[2] read_MemoryData[1]=DCACHE_rdata[1]
+ read_MemoryData[0]=DCACHE_rdata[0] test_si=n6 test_so=n5
+ test_se=FE_OFN116_test_se_i SPCASCAN_N6=SPCASCAN_N6
+ FE_PT1_ICACHE_addr_i_25_=ICACHE_addr[25] SPCASCAN_N10=SPCASCAN_N10
+ FE_PT1_ICACHE_addr_i_23_=ICACHE_addr[23] SPCASCAN_N30=SPCASCAN_N30
+ SPCASCAN_N31=SPCASCAN_N31 SPCASCAN_N32=SPCASCAN_N32 SPCASCAN_N33=SPCASCAN_N33
+ SPCASCAN_N34=SPCASCAN_N34 SPCASCAN_N35=SPCASCAN_N35 SPCASCAN_N36=SPCASCAN_N36
+ SPCASCAN_N37=SPCASCAN_N37 FE_OFN14_test_se_i=FE_OFN97_test_se_i
+ FE_OFN18_test_se_i=FE_OFN18_test_se_i FE_OFN4_test_se_i=FE_OFN4_test_se_i
+ FE_OFN5_test_se_i=FE_OFN5_test_se_i FE_OFN8_test_se_i=FE_OFN110_test_se_i
+ SPCBSCAN_N41=SPCBSCAN_N41 SPCBSCAN_N42=SPCBSCAN_N42
+ FE_OFN51_test_se_i=FE_OFN51_test_se_i FE_OFN53_test_se_i=FE_OFN53_test_se_i
+ FE_OFN54_test_se_i=FE_OFN54_test_se_i clk_i__L3_N19=clk_i__L3_N19
+ clk_i__L3_N27=clk_i__L3_N27 clk_i__L3_N9=clk_i__L3_N9
.ENDS

.SUBCKT CHIP clk rst ICACHE_addr[31] ICACHE_addr[30] ICACHE_addr[29]
+ ICACHE_addr[28] ICACHE_addr[27] ICACHE_addr[26] ICACHE_addr[25]
+ ICACHE_addr[24] ICACHE_addr[23] ICACHE_addr[22] ICACHE_addr[21]
+ ICACHE_addr[20] ICACHE_addr[19] ICACHE_addr[18] ICACHE_addr[17]
+ ICACHE_addr[16] ICACHE_addr[15] ICACHE_addr[14] ICACHE_addr[13]
+ ICACHE_addr[12] ICACHE_addr[11] ICACHE_addr[10] ICACHE_addr[9] ICACHE_addr[8]
+ ICACHE_addr[7] ICACHE_addr[6] ICACHE_addr[5] ICACHE_addr[4] ICACHE_addr[3]
+ ICACHE_addr[2] ICACHE_addr[1] ICACHE_addr[0] ICACHE_rdata[31]
+ ICACHE_rdata[30] ICACHE_rdata[29] ICACHE_rdata[28] ICACHE_rdata[27]
+ ICACHE_rdata[26] ICACHE_rdata[25] ICACHE_rdata[24] ICACHE_rdata[23]
+ ICACHE_rdata[22] ICACHE_rdata[21] ICACHE_rdata[20] ICACHE_rdata[19]
+ ICACHE_rdata[18] ICACHE_rdata[17] ICACHE_rdata[16] ICACHE_rdata[15]
+ ICACHE_rdata[14] ICACHE_rdata[13] ICACHE_rdata[12] ICACHE_rdata[11]
+ ICACHE_rdata[10] ICACHE_rdata[9] ICACHE_rdata[8] ICACHE_rdata[7]
+ ICACHE_rdata[6] ICACHE_rdata[5] ICACHE_rdata[4] ICACHE_rdata[3]
+ ICACHE_rdata[2] ICACHE_rdata[1] ICACHE_rdata[0] ICACHE_ren ICACHE_wen
+ ICACHE_wdata[31] ICACHE_wdata[30] ICACHE_wdata[29] ICACHE_wdata[28]
+ ICACHE_wdata[27] ICACHE_wdata[26] ICACHE_wdata[25] ICACHE_wdata[24]
+ ICACHE_wdata[23] ICACHE_wdata[22] ICACHE_wdata[21] ICACHE_wdata[20]
+ ICACHE_wdata[19] ICACHE_wdata[18] ICACHE_wdata[17] ICACHE_wdata[16]
+ ICACHE_wdata[15] ICACHE_wdata[14] ICACHE_wdata[13] ICACHE_wdata[12]
+ ICACHE_wdata[11] ICACHE_wdata[10] ICACHE_wdata[9] ICACHE_wdata[8]
+ ICACHE_wdata[7] ICACHE_wdata[6] ICACHE_wdata[5] ICACHE_wdata[4]
+ ICACHE_wdata[3] ICACHE_wdata[2] ICACHE_wdata[1] ICACHE_wdata[0] ICACHE_stall
+ DCACHE_addr[31] DCACHE_addr[30] DCACHE_addr[29] DCACHE_addr[28]
+ DCACHE_addr[27] DCACHE_addr[26] DCACHE_addr[25] DCACHE_addr[24]
+ DCACHE_addr[23] DCACHE_addr[22] DCACHE_addr[21] DCACHE_addr[20]
+ DCACHE_addr[19] DCACHE_addr[18] DCACHE_addr[17] DCACHE_addr[16]
+ DCACHE_addr[15] DCACHE_addr[14] DCACHE_addr[13] DCACHE_addr[12]
+ DCACHE_addr[11] DCACHE_addr[10] DCACHE_addr[9] DCACHE_addr[8] DCACHE_addr[7]
+ DCACHE_addr[6] DCACHE_addr[5] DCACHE_addr[4] DCACHE_addr[3] DCACHE_addr[2]
+ DCACHE_addr[1] DCACHE_addr[0] DCACHE_rdata[31] DCACHE_rdata[30]
+ DCACHE_rdata[29] DCACHE_rdata[28] DCACHE_rdata[27] DCACHE_rdata[26]
+ DCACHE_rdata[25] DCACHE_rdata[24] DCACHE_rdata[23] DCACHE_rdata[22]
+ DCACHE_rdata[21] DCACHE_rdata[20] DCACHE_rdata[19] DCACHE_rdata[18]
+ DCACHE_rdata[17] DCACHE_rdata[16] DCACHE_rdata[15] DCACHE_rdata[14]
+ DCACHE_rdata[13] DCACHE_rdata[12] DCACHE_rdata[11] DCACHE_rdata[10]
+ DCACHE_rdata[9] DCACHE_rdata[8] DCACHE_rdata[7] DCACHE_rdata[6]
+ DCACHE_rdata[5] DCACHE_rdata[4] DCACHE_rdata[3] DCACHE_rdata[2]
+ DCACHE_rdata[1] DCACHE_rdata[0] DCACHE_ren DCACHE_wen DCACHE_wdata[31]
+ DCACHE_wdata[30] DCACHE_wdata[29] DCACHE_wdata[28] DCACHE_wdata[27]
+ DCACHE_wdata[26] DCACHE_wdata[25] DCACHE_wdata[24] DCACHE_wdata[23]
+ DCACHE_wdata[22] DCACHE_wdata[21] DCACHE_wdata[20] DCACHE_wdata[19]
+ DCACHE_wdata[18] DCACHE_wdata[17] DCACHE_wdata[16] DCACHE_wdata[15]
+ DCACHE_wdata[14] DCACHE_wdata[13] DCACHE_wdata[12] DCACHE_wdata[11]
+ DCACHE_wdata[10] DCACHE_wdata[9] DCACHE_wdata[8] DCACHE_wdata[7]
+ DCACHE_wdata[6] DCACHE_wdata[5] DCACHE_wdata[4] DCACHE_wdata[3]
+ DCACHE_wdata[2] DCACHE_wdata[1] DCACHE_wdata[0] DCACHE_stall test_si test_so
+ test_se
Xclk_i__L3_I27 CLKINVX12 $PINS Y=clk_i__L3_N27 A=clk_i__L2_N7
Xclk_i__L3_I26 CLKINVX12 $PINS Y=clk_i__L3_N26 A=clk_i__L2_N7
Xclk_i__L3_I25 CLKINVX12 $PINS Y=clk_i__L3_N25 A=clk_i__L2_N7
Xclk_i__L3_I24 CLKINVX12 $PINS Y=clk_i__L3_N24 A=clk_i__L2_N7
Xclk_i__L3_I23 CLKINVX12 $PINS Y=clk_i__L3_N23 A=clk_i__L2_N6
Xclk_i__L3_I22 CLKINVX12 $PINS Y=clk_i__L3_N22 A=clk_i__L2_N6
Xclk_i__L3_I21 CLKINVX12 $PINS Y=clk_i__L3_N21 A=clk_i__L2_N6
Xclk_i__L3_I20 CLKINVX12 $PINS Y=clk_i__L3_N20 A=clk_i__L2_N6
Xclk_i__L3_I19 CLKINVX12 $PINS Y=clk_i__L3_N19 A=clk_i__L2_N5
Xclk_i__L3_I18 CLKINVX12 $PINS Y=clk_i__L3_N18 A=clk_i__L2_N5
Xclk_i__L3_I17 CLKINVX12 $PINS Y=clk_i__L3_N17 A=clk_i__L2_N5
Xclk_i__L3_I16 CLKINVX12 $PINS Y=clk_i__L3_N16 A=clk_i__L2_N5
Xclk_i__L3_I15 CLKINVX12 $PINS Y=clk_i__L3_N15 A=clk_i__L2_N4
Xclk_i__L3_I14 CLKINVX12 $PINS Y=clk_i__L3_N14 A=clk_i__L2_N4
Xclk_i__L3_I13 CLKINVX12 $PINS Y=clk_i__L3_N13 A=clk_i__L2_N4
Xclk_i__L3_I12 CLKINVX16 $PINS Y=clk_i__L3_N12 A=clk_i__L2_N4
Xclk_i__L3_I11 CLKINVX12 $PINS Y=clk_i__L3_N11 A=clk_i__L2_N3
Xclk_i__L3_I10 CLKINVX12 $PINS Y=clk_i__L3_N10 A=clk_i__L2_N3
Xclk_i__L3_I9 CLKINVX12 $PINS Y=clk_i__L3_N9 A=clk_i__L2_N3
Xclk_i__L3_I8 CLKINVX12 $PINS Y=clk_i__L3_N8 A=clk_i__L2_N2
Xclk_i__L3_I7 CLKINVX12 $PINS Y=clk_i__L3_N7 A=clk_i__L2_N2
Xclk_i__L3_I6 CLKINVX12 $PINS Y=clk_i__L3_N6 A=clk_i__L2_N2
Xclk_i__L3_I5 CLKINVX12 $PINS Y=clk_i__L3_N5 A=clk_i__L2_N1
Xclk_i__L3_I4 CLKINVX12 $PINS Y=clk_i__L3_N4 A=clk_i__L2_N1
Xclk_i__L3_I3 CLKINVX12 $PINS Y=clk_i__L3_N3 A=clk_i__L2_N1
Xclk_i__L3_I2 CLKINVX12 $PINS Y=clk_i__L3_N2 A=clk_i__L2_N0
Xclk_i__L3_I1 CLKINVX12 $PINS Y=clk_i__L3_N1 A=clk_i__L2_N0
Xclk_i__L3_I0 CLKINVX12 $PINS Y=clk_i__L3_N0 A=clk_i__L2_N0
Xclk_i__L2_I7 CLKBUFX20 $PINS Y=clk_i__L2_N7 A=clk_i__L1_N0
Xclk_i__L2_I6 CLKBUFX20 $PINS Y=clk_i__L2_N6 A=clk_i__L1_N0
Xclk_i__L2_I5 CLKBUFX20 $PINS Y=clk_i__L2_N5 A=clk_i__L1_N0
Xclk_i__L2_I4 CLKBUFX20 $PINS Y=clk_i__L2_N4 A=clk_i__L1_N0
Xclk_i__L2_I3 CLKBUFX16 $PINS Y=clk_i__L2_N3 A=clk_i__L1_N0
Xclk_i__L2_I2 CLKBUFX16 $PINS Y=clk_i__L2_N2 A=clk_i__L1_N0
Xclk_i__L2_I1 CLKBUFX20 $PINS Y=clk_i__L2_N1 A=clk_i__L1_N0
Xclk_i__L2_I0 CLKBUFX16 $PINS Y=clk_i__L2_N0 A=clk_i__L1_N0
Xclk_i__L1_I0 CLKINVX20 $PINS Y=clk_i__L1_N0 A=clk_i
XLTIE_LTIELO_7 TIELO $PINS Y=LTIE_LTIELO_7_NET
XLTIE_LTIELO_6 TIELO $PINS Y=LTIE_LTIELO_6_NET
XLTIE_LTIELO_5 TIELO $PINS Y=LTIE_LTIELO_5_NET
XLTIE_LTIELO_4 TIELO $PINS Y=LTIE_LTIELO_4_NET
XLTIE_LTIELO_3 TIELO $PINS Y=LTIE_LTIELO_3_NET
XLTIE_LTIELO_2 TIELO $PINS Y=LTIE_LTIELO_2_NET
XLTIE_LTIELO_1 TIELO $PINS Y=LTIE_LTIELO_1_NET
XLTIE_LTIELO TIELO $PINS Y=LTIE_LTIELO_NET
XLTIE_LTIEHI TIEHI $PINS Y=LTIE_LTIEHI_NET
Xipad_clk PDIDGZ $PINS PAD=clk C=clk_i
Xipad_rst PDIDGZ $PINS PAD=rst C=rst_i
Xipad_ICACHE_stall PDIDGZ $PINS PAD=ICACHE_stall C=ICACHE_stall_i
Xipad_DCACHE_stall PDIDGZ $PINS PAD=DCACHE_stall C=DCACHE_stall_i
Xipad_test_si PDIDGZ $PINS PAD=test_si C=test_si_i
Xipad_test_se PDIDGZ $PINS PAD=test_se C=test_se_i
Xipad_ICACHE_rdata0 PDIDGZ $PINS PAD=ICACHE_rdata[0] C=ICACHE_rdata_i[0]
Xipad_ICACHE_rdata1 PDIDGZ $PINS PAD=ICACHE_rdata[1] C=ICACHE_rdata_i[1]
Xipad_ICACHE_rdata2 PDIDGZ $PINS PAD=ICACHE_rdata[2] C=ICACHE_rdata_i[2]
Xipad_ICACHE_rdata3 PDIDGZ $PINS PAD=ICACHE_rdata[3] C=ICACHE_rdata_i[3]
Xipad_ICACHE_rdata4 PDIDGZ $PINS PAD=ICACHE_rdata[4] C=ICACHE_rdata_i[4]
Xipad_ICACHE_rdata5 PDIDGZ $PINS PAD=ICACHE_rdata[5] C=ICACHE_rdata_i[5]
Xipad_ICACHE_rdata6 PDIDGZ $PINS PAD=ICACHE_rdata[6] C=ICACHE_rdata_i[6]
Xipad_ICACHE_rdata7 PDIDGZ $PINS PAD=ICACHE_rdata[7] C=ICACHE_rdata_i[7]
Xipad_ICACHE_rdata8 PDIDGZ $PINS PAD=ICACHE_rdata[8] C=ICACHE_rdata_i[8]
Xipad_ICACHE_rdata9 PDIDGZ $PINS PAD=ICACHE_rdata[9] C=ICACHE_rdata_i[9]
Xipad_ICACHE_rdata10 PDIDGZ $PINS PAD=ICACHE_rdata[10] C=ICACHE_rdata_i[10]
Xipad_ICACHE_rdata11 PDIDGZ $PINS PAD=ICACHE_rdata[11] C=ICACHE_rdata_i[11]
Xipad_ICACHE_rdata12 PDIDGZ $PINS PAD=ICACHE_rdata[12] C=ICACHE_rdata_i[12]
Xipad_ICACHE_rdata13 PDIDGZ $PINS PAD=ICACHE_rdata[13] C=ICACHE_rdata_i[13]
Xipad_ICACHE_rdata14 PDIDGZ $PINS PAD=ICACHE_rdata[14] C=ICACHE_rdata_i[14]
Xipad_ICACHE_rdata15 PDIDGZ $PINS PAD=ICACHE_rdata[15] C=ICACHE_rdata_i[15]
Xipad_ICACHE_rdata16 PDIDGZ $PINS PAD=ICACHE_rdata[16] C=ICACHE_rdata_i[16]
Xipad_ICACHE_rdata17 PDIDGZ $PINS PAD=ICACHE_rdata[17] C=ICACHE_rdata_i[17]
Xipad_ICACHE_rdata18 PDIDGZ $PINS PAD=ICACHE_rdata[18] C=ICACHE_rdata_i[18]
Xipad_ICACHE_rdata19 PDIDGZ $PINS PAD=ICACHE_rdata[19] C=ICACHE_rdata_i[19]
Xipad_ICACHE_rdata20 PDIDGZ $PINS PAD=ICACHE_rdata[20] C=ICACHE_rdata_i[20]
Xipad_ICACHE_rdata21 PDIDGZ $PINS PAD=ICACHE_rdata[21] C=ICACHE_rdata_i[21]
Xipad_ICACHE_rdata22 PDIDGZ $PINS PAD=ICACHE_rdata[22] C=ICACHE_rdata_i[22]
Xipad_ICACHE_rdata23 PDIDGZ $PINS PAD=ICACHE_rdata[23] C=ICACHE_rdata_i[23]
Xipad_ICACHE_rdata24 PDIDGZ $PINS PAD=ICACHE_rdata[24] C=ICACHE_rdata_i[24]
Xipad_ICACHE_rdata25 PDIDGZ $PINS PAD=ICACHE_rdata[25] C=ICACHE_rdata_i[25]
Xipad_ICACHE_rdata26 PDIDGZ $PINS PAD=ICACHE_rdata[26] C=ICACHE_rdata_i[26]
Xipad_ICACHE_rdata27 PDIDGZ $PINS PAD=ICACHE_rdata[27] C=ICACHE_rdata_i[27]
Xipad_ICACHE_rdata28 PDIDGZ $PINS PAD=ICACHE_rdata[28] C=ICACHE_rdata_i[28]
Xipad_ICACHE_rdata29 PDIDGZ $PINS PAD=ICACHE_rdata[29] C=ICACHE_rdata_i[29]
Xipad_ICACHE_rdata30 PDIDGZ $PINS PAD=ICACHE_rdata[30] C=ICACHE_rdata_i[30]
Xipad_ICACHE_rdata31 PDIDGZ $PINS PAD=ICACHE_rdata[31] C=ICACHE_rdata_i[31]
Xipad_DCACHE_rdata0 PDIDGZ $PINS PAD=DCACHE_rdata[0] C=DCACHE_rdata_i[0]
Xipad_DCACHE_rdata1 PDIDGZ $PINS PAD=DCACHE_rdata[1] C=DCACHE_rdata_i[1]
Xipad_DCACHE_rdata2 PDIDGZ $PINS PAD=DCACHE_rdata[2] C=DCACHE_rdata_i[2]
Xipad_DCACHE_rdata3 PDIDGZ $PINS PAD=DCACHE_rdata[3] C=DCACHE_rdata_i[3]
Xipad_DCACHE_rdata4 PDIDGZ $PINS PAD=DCACHE_rdata[4] C=DCACHE_rdata_i[4]
Xipad_DCACHE_rdata5 PDIDGZ $PINS PAD=DCACHE_rdata[5] C=DCACHE_rdata_i[5]
Xipad_DCACHE_rdata6 PDIDGZ $PINS PAD=DCACHE_rdata[6] C=DCACHE_rdata_i[6]
Xipad_DCACHE_rdata7 PDIDGZ $PINS PAD=DCACHE_rdata[7] C=DCACHE_rdata_i[7]
Xipad_DCACHE_rdata8 PDIDGZ $PINS PAD=DCACHE_rdata[8] C=DCACHE_rdata_i[8]
Xipad_DCACHE_rdata9 PDIDGZ $PINS PAD=DCACHE_rdata[9] C=DCACHE_rdata_i[9]
Xipad_DCACHE_rdata10 PDIDGZ $PINS PAD=DCACHE_rdata[10] C=DCACHE_rdata_i[10]
Xipad_DCACHE_rdata11 PDIDGZ $PINS PAD=DCACHE_rdata[11] C=DCACHE_rdata_i[11]
Xipad_DCACHE_rdata12 PDIDGZ $PINS PAD=DCACHE_rdata[12] C=DCACHE_rdata_i[12]
Xipad_DCACHE_rdata13 PDIDGZ $PINS PAD=DCACHE_rdata[13] C=DCACHE_rdata_i[13]
Xipad_DCACHE_rdata14 PDIDGZ $PINS PAD=DCACHE_rdata[14] C=DCACHE_rdata_i[14]
Xipad_DCACHE_rdata15 PDIDGZ $PINS PAD=DCACHE_rdata[15] C=DCACHE_rdata_i[15]
Xipad_DCACHE_rdata16 PDIDGZ $PINS PAD=DCACHE_rdata[16] C=DCACHE_rdata_i[16]
Xipad_DCACHE_rdata17 PDIDGZ $PINS PAD=DCACHE_rdata[17] C=DCACHE_rdata_i[17]
Xipad_DCACHE_rdata18 PDIDGZ $PINS PAD=DCACHE_rdata[18] C=DCACHE_rdata_i[18]
Xipad_DCACHE_rdata19 PDIDGZ $PINS PAD=DCACHE_rdata[19] C=DCACHE_rdata_i[19]
Xipad_DCACHE_rdata20 PDIDGZ $PINS PAD=DCACHE_rdata[20] C=DCACHE_rdata_i[20]
Xipad_DCACHE_rdata21 PDIDGZ $PINS PAD=DCACHE_rdata[21] C=DCACHE_rdata_i[21]
Xipad_DCACHE_rdata22 PDIDGZ $PINS PAD=DCACHE_rdata[22] C=DCACHE_rdata_i[22]
Xipad_DCACHE_rdata23 PDIDGZ $PINS PAD=DCACHE_rdata[23] C=DCACHE_rdata_i[23]
Xipad_DCACHE_rdata24 PDIDGZ $PINS PAD=DCACHE_rdata[24] C=DCACHE_rdata_i[24]
Xipad_DCACHE_rdata25 PDIDGZ $PINS PAD=DCACHE_rdata[25] C=DCACHE_rdata_i[25]
Xipad_DCACHE_rdata26 PDIDGZ $PINS PAD=DCACHE_rdata[26] C=DCACHE_rdata_i[26]
Xipad_DCACHE_rdata27 PDIDGZ $PINS PAD=DCACHE_rdata[27] C=DCACHE_rdata_i[27]
Xipad_DCACHE_rdata28 PDIDGZ $PINS PAD=DCACHE_rdata[28] C=DCACHE_rdata_i[28]
Xipad_DCACHE_rdata29 PDIDGZ $PINS PAD=DCACHE_rdata[29] C=DCACHE_rdata_i[29]
Xipad_DCACHE_rdata30 PDIDGZ $PINS PAD=DCACHE_rdata[30] C=DCACHE_rdata_i[30]
Xipad_DCACHE_rdata31 PDIDGZ $PINS PAD=DCACHE_rdata[31] C=DCACHE_rdata_i[31]
Xopad_ICACHE_ren PDO02CDG $PINS PAD=ICACHE_ren I=LTIE_LTIEHI_NET
Xopad_ICACHE_wen PDO02CDG $PINS PAD=ICACHE_wen I=LTIE_LTIELO_3_NET
Xopad_DCACHE_ren PDO02CDG $PINS PAD=DCACHE_ren I=DCACHE_ren_i
Xopad_DCACHE_wen PDO02CDG $PINS PAD=DCACHE_wen I=DCACHE_wen_i
Xopad_test_so PDO02CDG $PINS PAD=test_so I=ICACHE_addr_i[24]
Xopad_ICACHE_addr0 PDO02CDG $PINS PAD=ICACHE_addr[0] I=ICACHE_addr_i[0]
Xopad_ICACHE_addr1 PDO02CDG $PINS PAD=ICACHE_addr[1] I=ICACHE_addr_i[1]
Xopad_ICACHE_addr2 PDO02CDG $PINS PAD=ICACHE_addr[2] I=ICACHE_addr_i[2]
Xopad_ICACHE_addr3 PDO02CDG $PINS PAD=ICACHE_addr[3] I=ICACHE_addr_i[3]
Xopad_ICACHE_addr4 PDO02CDG $PINS PAD=ICACHE_addr[4] I=ICACHE_addr_i[4]
Xopad_ICACHE_addr5 PDO02CDG $PINS PAD=ICACHE_addr[5] I=ICACHE_addr_i[5]
Xopad_ICACHE_addr6 PDO02CDG $PINS PAD=ICACHE_addr[6] I=ICACHE_addr_i[6]
Xopad_ICACHE_addr7 PDO02CDG $PINS PAD=ICACHE_addr[7] I=ICACHE_addr_i[7]
Xopad_ICACHE_addr8 PDO02CDG $PINS PAD=ICACHE_addr[8] I=ICACHE_addr_i[8]
Xopad_ICACHE_addr9 PDO02CDG $PINS PAD=ICACHE_addr[9] I=ICACHE_addr_i[9]
Xopad_ICACHE_addr10 PDO02CDG $PINS PAD=ICACHE_addr[10] I=ICACHE_addr_i[10]
Xopad_ICACHE_addr11 PDO02CDG $PINS PAD=ICACHE_addr[11] I=ICACHE_addr_i[11]
Xopad_ICACHE_addr12 PDO02CDG $PINS PAD=ICACHE_addr[12] I=ICACHE_addr_i[12]
Xopad_ICACHE_addr13 PDO02CDG $PINS PAD=ICACHE_addr[13] I=ICACHE_addr_i[13]
Xopad_ICACHE_addr14 PDO02CDG $PINS PAD=ICACHE_addr[14] I=ICACHE_addr_i[14]
Xopad_ICACHE_addr15 PDO02CDG $PINS PAD=ICACHE_addr[15] I=ICACHE_addr_i[15]
Xopad_ICACHE_addr16 PDO02CDG $PINS PAD=ICACHE_addr[16] I=ICACHE_addr_i[16]
Xopad_ICACHE_addr17 PDO02CDG $PINS PAD=ICACHE_addr[17] I=ICACHE_addr_i[17]
Xopad_ICACHE_addr18 PDO02CDG $PINS PAD=ICACHE_addr[18] I=ICACHE_addr_i[18]
Xopad_ICACHE_addr19 PDO02CDG $PINS PAD=ICACHE_addr[19] I=ICACHE_addr_i[19]
Xopad_ICACHE_addr20 PDO02CDG $PINS PAD=ICACHE_addr[20] I=ICACHE_addr_i[20]
Xopad_ICACHE_addr21 PDO02CDG $PINS PAD=ICACHE_addr[21] I=ICACHE_addr_i[21]
Xopad_ICACHE_addr22 PDO02CDG $PINS PAD=ICACHE_addr[22] I=ICACHE_addr_i[22]
Xopad_ICACHE_addr23 PDO02CDG $PINS PAD=ICACHE_addr[23] I=ICACHE_addr_i[23]
Xopad_ICACHE_addr24 PDO02CDG $PINS PAD=ICACHE_addr[24] I=ICACHE_addr_i[24]
Xopad_ICACHE_addr25 PDO02CDG $PINS PAD=ICACHE_addr[25] I=ICACHE_addr_i[25]
Xopad_ICACHE_addr26 PDO02CDG $PINS PAD=ICACHE_addr[26] I=ICACHE_addr_i[26]
Xopad_ICACHE_addr27 PDO02CDG $PINS PAD=ICACHE_addr[27] I=ICACHE_addr_i[27]
Xopad_ICACHE_addr28 PDO02CDG $PINS PAD=ICACHE_addr[28] I=ICACHE_addr_i[28]
Xopad_ICACHE_addr29 PDO02CDG $PINS PAD=ICACHE_addr[29] I=ICACHE_addr_i[29]
Xopad_ICACHE_addr30 PDO02CDG $PINS PAD=ICACHE_addr[30] I=ICACHE_addr_i[30]
Xopad_ICACHE_addr31 PDO02CDG $PINS PAD=ICACHE_addr[31] I=ICACHE_addr_i[31]
Xopad_DCACHE_addr0 PDO02CDG $PINS PAD=DCACHE_addr[0] I=DCACHE_addr_i[0]
Xopad_DCACHE_addr1 PDO02CDG $PINS PAD=DCACHE_addr[1] I=DCACHE_addr_i[1]
Xopad_DCACHE_addr2 PDO02CDG $PINS PAD=DCACHE_addr[2] I=DCACHE_addr_i[2]
Xopad_DCACHE_addr3 PDO02CDG $PINS PAD=DCACHE_addr[3] I=DCACHE_addr_i[3]
Xopad_DCACHE_addr4 PDO02CDG $PINS PAD=DCACHE_addr[4] I=DCACHE_addr_i[4]
Xopad_DCACHE_addr5 PDO02CDG $PINS PAD=DCACHE_addr[5] I=DCACHE_addr_i[5]
Xopad_DCACHE_addr6 PDO02CDG $PINS PAD=DCACHE_addr[6] I=DCACHE_addr_i[6]
Xopad_DCACHE_addr7 PDO02CDG $PINS PAD=DCACHE_addr[7] I=DCACHE_addr_i[7]
Xopad_DCACHE_addr8 PDO02CDG $PINS PAD=DCACHE_addr[8] I=DCACHE_addr_i[8]
Xopad_DCACHE_addr9 PDO02CDG $PINS PAD=DCACHE_addr[9] I=DCACHE_addr_i[9]
Xopad_DCACHE_addr10 PDO02CDG $PINS PAD=DCACHE_addr[10] I=DCACHE_addr_i[10]
Xopad_DCACHE_addr11 PDO02CDG $PINS PAD=DCACHE_addr[11] I=DCACHE_addr_i[11]
Xopad_DCACHE_addr12 PDO02CDG $PINS PAD=DCACHE_addr[12] I=DCACHE_addr_i[12]
Xopad_DCACHE_addr13 PDO02CDG $PINS PAD=DCACHE_addr[13] I=DCACHE_addr_i[13]
Xopad_DCACHE_addr14 PDO02CDG $PINS PAD=DCACHE_addr[14] I=DCACHE_addr_i[14]
Xopad_DCACHE_addr15 PDO02CDG $PINS PAD=DCACHE_addr[15] I=DCACHE_addr_i[15]
Xopad_DCACHE_addr16 PDO02CDG $PINS PAD=DCACHE_addr[16] I=DCACHE_addr_i[16]
Xopad_DCACHE_addr17 PDO02CDG $PINS PAD=DCACHE_addr[17] I=DCACHE_addr_i[17]
Xopad_DCACHE_addr18 PDO02CDG $PINS PAD=DCACHE_addr[18] I=DCACHE_addr_i[18]
Xopad_DCACHE_addr19 PDO02CDG $PINS PAD=DCACHE_addr[19] I=DCACHE_addr_i[19]
Xopad_DCACHE_addr20 PDO02CDG $PINS PAD=DCACHE_addr[20] I=DCACHE_addr_i[20]
Xopad_DCACHE_addr21 PDO02CDG $PINS PAD=DCACHE_addr[21] I=DCACHE_addr_i[21]
Xopad_DCACHE_addr22 PDO02CDG $PINS PAD=DCACHE_addr[22] I=DCACHE_addr_i[22]
Xopad_DCACHE_addr23 PDO02CDG $PINS PAD=DCACHE_addr[23] I=DCACHE_addr_i[23]
Xopad_DCACHE_addr24 PDO02CDG $PINS PAD=DCACHE_addr[24] I=DCACHE_addr_i[24]
Xopad_DCACHE_addr25 PDO02CDG $PINS PAD=DCACHE_addr[25] I=DCACHE_addr_i[25]
Xopad_DCACHE_addr26 PDO02CDG $PINS PAD=DCACHE_addr[26] I=DCACHE_addr_i[26]
Xopad_DCACHE_addr27 PDO02CDG $PINS PAD=DCACHE_addr[27] I=DCACHE_addr_i[27]
Xopad_DCACHE_addr28 PDO02CDG $PINS PAD=DCACHE_addr[28] I=DCACHE_addr_i[28]
Xopad_DCACHE_addr29 PDO02CDG $PINS PAD=DCACHE_addr[29] I=DCACHE_addr_i[29]
Xopad_DCACHE_addr30 PDO02CDG $PINS PAD=DCACHE_addr[30] I=DCACHE_addr_i[30]
Xopad_DCACHE_addr31 PDO02CDG $PINS PAD=DCACHE_addr[31] I=DCACHE_addr_i[31]
Xopad_ICACHE_wdata0 PDO02CDG $PINS PAD=ICACHE_wdata[0] I=LTIE_LTIELO_2_NET
Xopad_ICACHE_wdata1 PDO02CDG $PINS PAD=ICACHE_wdata[1] I=LTIE_LTIELO_2_NET
Xopad_ICACHE_wdata2 PDO02CDG $PINS PAD=ICACHE_wdata[2] I=LTIE_LTIELO_2_NET
Xopad_ICACHE_wdata3 PDO02CDG $PINS PAD=ICACHE_wdata[3] I=LTIE_LTIELO_1_NET
Xopad_ICACHE_wdata4 PDO02CDG $PINS PAD=ICACHE_wdata[4] I=LTIE_LTIELO_1_NET
Xopad_ICACHE_wdata5 PDO02CDG $PINS PAD=ICACHE_wdata[5] I=LTIE_LTIELO_1_NET
Xopad_ICACHE_wdata6 PDO02CDG $PINS PAD=ICACHE_wdata[6] I=LTIE_LTIELO_1_NET
Xopad_ICACHE_wdata7 PDO02CDG $PINS PAD=ICACHE_wdata[7] I=LTIE_LTIELO_1_NET
Xopad_ICACHE_wdata8 PDO02CDG $PINS PAD=ICACHE_wdata[8] I=LTIE_LTIELO_NET
Xopad_ICACHE_wdata9 PDO02CDG $PINS PAD=ICACHE_wdata[9] I=LTIE_LTIELO_NET
Xopad_ICACHE_wdata10 PDO02CDG $PINS PAD=ICACHE_wdata[10] I=LTIE_LTIELO_NET
Xopad_ICACHE_wdata11 PDO02CDG $PINS PAD=ICACHE_wdata[11] I=LTIE_LTIELO_NET
Xopad_ICACHE_wdata12 PDO02CDG $PINS PAD=ICACHE_wdata[12] I=LTIE_LTIELO_NET
Xopad_ICACHE_wdata13 PDO02CDG $PINS PAD=ICACHE_wdata[13] I=LTIE_LTIELO_7_NET
Xopad_ICACHE_wdata14 PDO02CDG $PINS PAD=ICACHE_wdata[14] I=LTIE_LTIELO_6_NET
Xopad_ICACHE_wdata15 PDO02CDG $PINS PAD=ICACHE_wdata[15] I=LTIE_LTIELO_6_NET
Xopad_ICACHE_wdata16 PDO02CDG $PINS PAD=ICACHE_wdata[16] I=LTIE_LTIELO_6_NET
Xopad_ICACHE_wdata17 PDO02CDG $PINS PAD=ICACHE_wdata[17] I=LTIE_LTIELO_6_NET
Xopad_ICACHE_wdata18 PDO02CDG $PINS PAD=ICACHE_wdata[18] I=LTIE_LTIELO_6_NET
Xopad_ICACHE_wdata19 PDO02CDG $PINS PAD=ICACHE_wdata[19] I=LTIE_LTIELO_6_NET
Xopad_ICACHE_wdata20 PDO02CDG $PINS PAD=ICACHE_wdata[20] I=LTIE_LTIELO_5_NET
Xopad_ICACHE_wdata21 PDO02CDG $PINS PAD=ICACHE_wdata[21] I=LTIE_LTIELO_5_NET
Xopad_ICACHE_wdata22 PDO02CDG $PINS PAD=ICACHE_wdata[22] I=LTIE_LTIELO_5_NET
Xopad_ICACHE_wdata23 PDO02CDG $PINS PAD=ICACHE_wdata[23] I=LTIE_LTIELO_5_NET
Xopad_ICACHE_wdata24 PDO02CDG $PINS PAD=ICACHE_wdata[24] I=LTIE_LTIELO_5_NET
Xopad_ICACHE_wdata25 PDO02CDG $PINS PAD=ICACHE_wdata[25] I=LTIE_LTIELO_5_NET
Xopad_ICACHE_wdata26 PDO02CDG $PINS PAD=ICACHE_wdata[26] I=LTIE_LTIELO_4_NET
Xopad_ICACHE_wdata27 PDO02CDG $PINS PAD=ICACHE_wdata[27] I=LTIE_LTIELO_4_NET
Xopad_ICACHE_wdata28 PDO02CDG $PINS PAD=ICACHE_wdata[28] I=LTIE_LTIELO_4_NET
Xopad_ICACHE_wdata29 PDO02CDG $PINS PAD=ICACHE_wdata[29] I=LTIE_LTIELO_4_NET
Xopad_ICACHE_wdata30 PDO02CDG $PINS PAD=ICACHE_wdata[30] I=LTIE_LTIELO_4_NET
Xopad_ICACHE_wdata31 PDO02CDG $PINS PAD=ICACHE_wdata[31] I=LTIE_LTIELO_4_NET
Xopad_DCACHE_wdata0 PDO02CDG $PINS PAD=DCACHE_wdata[0] I=DCACHE_wdata_i[0]
Xopad_DCACHE_wdata1 PDO02CDG $PINS PAD=DCACHE_wdata[1] I=DCACHE_wdata_i[1]
Xopad_DCACHE_wdata2 PDO02CDG $PINS PAD=DCACHE_wdata[2] I=DCACHE_wdata_i[2]
Xopad_DCACHE_wdata3 PDO02CDG $PINS PAD=DCACHE_wdata[3] I=DCACHE_wdata_i[3]
Xopad_DCACHE_wdata4 PDO02CDG $PINS PAD=DCACHE_wdata[4] I=DCACHE_wdata_i[4]
Xopad_DCACHE_wdata5 PDO02CDG $PINS PAD=DCACHE_wdata[5] I=DCACHE_wdata_i[5]
Xopad_DCACHE_wdata6 PDO02CDG $PINS PAD=DCACHE_wdata[6] I=DCACHE_wdata_i[6]
Xopad_DCACHE_wdata7 PDO02CDG $PINS PAD=DCACHE_wdata[7] I=DCACHE_wdata_i[7]
Xopad_DCACHE_wdata8 PDO02CDG $PINS PAD=DCACHE_wdata[8] I=DCACHE_wdata_i[8]
Xopad_DCACHE_wdata9 PDO02CDG $PINS PAD=DCACHE_wdata[9] I=DCACHE_wdata_i[9]
Xopad_DCACHE_wdata10 PDO02CDG $PINS PAD=DCACHE_wdata[10] I=DCACHE_wdata_i[10]
Xopad_DCACHE_wdata11 PDO02CDG $PINS PAD=DCACHE_wdata[11] I=DCACHE_wdata_i[11]
Xopad_DCACHE_wdata12 PDO02CDG $PINS PAD=DCACHE_wdata[12] I=DCACHE_wdata_i[12]
Xopad_DCACHE_wdata13 PDO02CDG $PINS PAD=DCACHE_wdata[13] I=DCACHE_wdata_i[13]
Xopad_DCACHE_wdata14 PDO02CDG $PINS PAD=DCACHE_wdata[14] I=DCACHE_wdata_i[14]
Xopad_DCACHE_wdata15 PDO02CDG $PINS PAD=DCACHE_wdata[15] I=DCACHE_wdata_i[15]
Xopad_DCACHE_wdata16 PDO02CDG $PINS PAD=DCACHE_wdata[16] I=DCACHE_wdata_i[16]
Xopad_DCACHE_wdata17 PDO02CDG $PINS PAD=DCACHE_wdata[17] I=DCACHE_wdata_i[17]
Xopad_DCACHE_wdata18 PDO02CDG $PINS PAD=DCACHE_wdata[18] I=DCACHE_wdata_i[18]
Xopad_DCACHE_wdata19 PDO02CDG $PINS PAD=DCACHE_wdata[19] I=DCACHE_wdata_i[19]
Xopad_DCACHE_wdata20 PDO02CDG $PINS PAD=DCACHE_wdata[20] I=DCACHE_wdata_i[20]
Xopad_DCACHE_wdata21 PDO02CDG $PINS PAD=DCACHE_wdata[21] I=DCACHE_wdata_i[21]
Xopad_DCACHE_wdata22 PDO02CDG $PINS PAD=DCACHE_wdata[22] I=DCACHE_wdata_i[22]
Xopad_DCACHE_wdata23 PDO02CDG $PINS PAD=DCACHE_wdata[23] I=DCACHE_wdata_i[23]
Xopad_DCACHE_wdata24 PDO02CDG $PINS PAD=DCACHE_wdata[24] I=DCACHE_wdata_i[24]
Xopad_DCACHE_wdata25 PDO02CDG $PINS PAD=DCACHE_wdata[25] I=DCACHE_wdata_i[25]
Xopad_DCACHE_wdata26 PDO02CDG $PINS PAD=DCACHE_wdata[26] I=DCACHE_wdata_i[26]
Xopad_DCACHE_wdata27 PDO02CDG $PINS PAD=DCACHE_wdata[27] I=DCACHE_wdata_i[27]
Xopad_DCACHE_wdata28 PDO02CDG $PINS PAD=DCACHE_wdata[28] I=DCACHE_wdata_i[28]
Xopad_DCACHE_wdata29 PDO02CDG $PINS PAD=DCACHE_wdata[29] I=DCACHE_wdata_i[29]
Xopad_DCACHE_wdata30 PDO02CDG $PINS PAD=DCACHE_wdata[30] I=DCACHE_wdata_i[30]
Xopad_DCACHE_wdata31 PDO02CDG $PINS PAD=DCACHE_wdata[31] I=DCACHE_wdata_i[31]
XMIPS MIPS_Pipeline $PINS clk=clk_i__L3_N0 rst=rst_i
+ ICACHE_addr[31]=ICACHE_addr_i[31] ICACHE_addr[30]=ICACHE_addr_i[30]
+ ICACHE_addr[29]=ICACHE_addr_i[29] ICACHE_addr[28]=ICACHE_addr_i[28]
+ ICACHE_addr[27]=ICACHE_addr_i[27] ICACHE_addr[26]=ICACHE_addr_i[26]
+ ICACHE_addr[25]=ICACHE_addr_i[25] ICACHE_addr[24]=ICACHE_addr_i[24]
+ ICACHE_addr[23]=ICACHE_addr_i[23] ICACHE_addr[22]=ICACHE_addr_i[22]
+ ICACHE_addr[21]=ICACHE_addr_i[21] ICACHE_addr[20]=ICACHE_addr_i[20]
+ ICACHE_addr[19]=ICACHE_addr_i[19] ICACHE_addr[18]=ICACHE_addr_i[18]
+ ICACHE_addr[17]=ICACHE_addr_i[17] ICACHE_addr[16]=ICACHE_addr_i[16]
+ ICACHE_addr[15]=ICACHE_addr_i[15] ICACHE_addr[14]=ICACHE_addr_i[14]
+ ICACHE_addr[13]=ICACHE_addr_i[13] ICACHE_addr[12]=ICACHE_addr_i[12]
+ ICACHE_addr[11]=ICACHE_addr_i[11] ICACHE_addr[10]=ICACHE_addr_i[10]
+ ICACHE_addr[9]=ICACHE_addr_i[9] ICACHE_addr[8]=ICACHE_addr_i[8]
+ ICACHE_addr[7]=ICACHE_addr_i[7] ICACHE_addr[6]=ICACHE_addr_i[6]
+ ICACHE_addr[5]=ICACHE_addr_i[5] ICACHE_addr[4]=ICACHE_addr_i[4]
+ ICACHE_addr[3]=ICACHE_addr_i[3] ICACHE_addr[2]=ICACHE_addr_i[2]
+ ICACHE_addr[1]=ICACHE_addr_i[1] ICACHE_addr[0]=ICACHE_addr_i[0]
+ ICACHE_rdata[31]=ICACHE_rdata_i[31] ICACHE_rdata[30]=ICACHE_rdata_i[30]
+ ICACHE_rdata[29]=ICACHE_rdata_i[29] ICACHE_rdata[28]=ICACHE_rdata_i[28]
+ ICACHE_rdata[27]=ICACHE_rdata_i[27] ICACHE_rdata[26]=ICACHE_rdata_i[26]
+ ICACHE_rdata[25]=ICACHE_rdata_i[25] ICACHE_rdata[24]=ICACHE_rdata_i[24]
+ ICACHE_rdata[23]=ICACHE_rdata_i[23] ICACHE_rdata[22]=ICACHE_rdata_i[22]
+ ICACHE_rdata[21]=ICACHE_rdata_i[21] ICACHE_rdata[20]=ICACHE_rdata_i[20]
+ ICACHE_rdata[19]=ICACHE_rdata_i[19] ICACHE_rdata[18]=ICACHE_rdata_i[18]
+ ICACHE_rdata[17]=ICACHE_rdata_i[17] ICACHE_rdata[16]=ICACHE_rdata_i[16]
+ ICACHE_rdata[15]=ICACHE_rdata_i[15] ICACHE_rdata[14]=ICACHE_rdata_i[14]
+ ICACHE_rdata[13]=ICACHE_rdata_i[13] ICACHE_rdata[12]=ICACHE_rdata_i[12]
+ ICACHE_rdata[11]=ICACHE_rdata_i[11] ICACHE_rdata[10]=ICACHE_rdata_i[10]
+ ICACHE_rdata[9]=ICACHE_rdata_i[9] ICACHE_rdata[8]=ICACHE_rdata_i[8]
+ ICACHE_rdata[7]=ICACHE_rdata_i[7] ICACHE_rdata[6]=ICACHE_rdata_i[6]
+ ICACHE_rdata[5]=ICACHE_rdata_i[5] ICACHE_rdata[4]=ICACHE_rdata_i[4]
+ ICACHE_rdata[3]=ICACHE_rdata_i[3] ICACHE_rdata[2]=ICACHE_rdata_i[2]
+ ICACHE_rdata[1]=ICACHE_rdata_i[1] ICACHE_rdata[0]=ICACHE_rdata_i[0]
+ ICACHE_ren=ICACHE_ren_i ICACHE_wen=ICACHE_wen_i
+ ICACHE_wdata[31]=ICACHE_wdata_i[31] ICACHE_wdata[30]=ICACHE_wdata_i[30]
+ ICACHE_wdata[29]=ICACHE_wdata_i[29] ICACHE_wdata[28]=ICACHE_wdata_i[28]
+ ICACHE_wdata[27]=ICACHE_wdata_i[27] ICACHE_wdata[26]=ICACHE_wdata_i[26]
+ ICACHE_wdata[25]=ICACHE_wdata_i[25] ICACHE_wdata[24]=ICACHE_wdata_i[24]
+ ICACHE_wdata[23]=ICACHE_wdata_i[23] ICACHE_wdata[22]=ICACHE_wdata_i[22]
+ ICACHE_wdata[21]=ICACHE_wdata_i[21] ICACHE_wdata[20]=ICACHE_wdata_i[20]
+ ICACHE_wdata[19]=ICACHE_wdata_i[19] ICACHE_wdata[18]=ICACHE_wdata_i[18]
+ ICACHE_wdata[17]=ICACHE_wdata_i[17] ICACHE_wdata[16]=ICACHE_wdata_i[16]
+ ICACHE_wdata[15]=ICACHE_wdata_i[15] ICACHE_wdata[14]=ICACHE_wdata_i[14]
+ ICACHE_wdata[13]=ICACHE_wdata_i[13] ICACHE_wdata[12]=ICACHE_wdata_i[12]
+ ICACHE_wdata[11]=ICACHE_wdata_i[11] ICACHE_wdata[10]=ICACHE_wdata_i[10]
+ ICACHE_wdata[9]=ICACHE_wdata_i[9] ICACHE_wdata[8]=ICACHE_wdata_i[8]
+ ICACHE_wdata[7]=ICACHE_wdata_i[7] ICACHE_wdata[6]=ICACHE_wdata_i[6]
+ ICACHE_wdata[5]=ICACHE_wdata_i[5] ICACHE_wdata[4]=ICACHE_wdata_i[4]
+ ICACHE_wdata[3]=ICACHE_wdata_i[3] ICACHE_wdata[2]=ICACHE_wdata_i[2]
+ ICACHE_wdata[1]=ICACHE_wdata_i[1] ICACHE_wdata[0]=ICACHE_wdata_i[0]
+ ICACHE_stall=ICACHE_stall_i DCACHE_addr[31]=DCACHE_addr_i[31]
+ DCACHE_addr[30]=DCACHE_addr_i[30] DCACHE_addr[29]=DCACHE_addr_i[29]
+ DCACHE_addr[28]=DCACHE_addr_i[28] DCACHE_addr[27]=DCACHE_addr_i[27]
+ DCACHE_addr[26]=DCACHE_addr_i[26] DCACHE_addr[25]=DCACHE_addr_i[25]
+ DCACHE_addr[24]=DCACHE_addr_i[24] DCACHE_addr[23]=DCACHE_addr_i[23]
+ DCACHE_addr[22]=DCACHE_addr_i[22] DCACHE_addr[21]=DCACHE_addr_i[21]
+ DCACHE_addr[20]=DCACHE_addr_i[20] DCACHE_addr[19]=DCACHE_addr_i[19]
+ DCACHE_addr[18]=DCACHE_addr_i[18] DCACHE_addr[17]=DCACHE_addr_i[17]
+ DCACHE_addr[16]=DCACHE_addr_i[16] DCACHE_addr[15]=DCACHE_addr_i[15]
+ DCACHE_addr[14]=DCACHE_addr_i[14] DCACHE_addr[13]=DCACHE_addr_i[13]
+ DCACHE_addr[12]=DCACHE_addr_i[12] DCACHE_addr[11]=DCACHE_addr_i[11]
+ DCACHE_addr[10]=DCACHE_addr_i[10] DCACHE_addr[9]=DCACHE_addr_i[9]
+ DCACHE_addr[8]=DCACHE_addr_i[8] DCACHE_addr[7]=DCACHE_addr_i[7]
+ DCACHE_addr[6]=DCACHE_addr_i[6] DCACHE_addr[5]=DCACHE_addr_i[5]
+ DCACHE_addr[4]=DCACHE_addr_i[4] DCACHE_addr[3]=DCACHE_addr_i[3]
+ DCACHE_addr[2]=DCACHE_addr_i[2] DCACHE_addr[1]=DCACHE_addr_i[1]
+ DCACHE_addr[0]=DCACHE_addr_i[0] DCACHE_rdata[31]=DCACHE_rdata_i[31]
+ DCACHE_rdata[30]=DCACHE_rdata_i[30] DCACHE_rdata[29]=DCACHE_rdata_i[29]
+ DCACHE_rdata[28]=DCACHE_rdata_i[28] DCACHE_rdata[27]=DCACHE_rdata_i[27]
+ DCACHE_rdata[26]=DCACHE_rdata_i[26] DCACHE_rdata[25]=DCACHE_rdata_i[25]
+ DCACHE_rdata[24]=DCACHE_rdata_i[24] DCACHE_rdata[23]=DCACHE_rdata_i[23]
+ DCACHE_rdata[22]=DCACHE_rdata_i[22] DCACHE_rdata[21]=DCACHE_rdata_i[21]
+ DCACHE_rdata[20]=DCACHE_rdata_i[20] DCACHE_rdata[19]=DCACHE_rdata_i[19]
+ DCACHE_rdata[18]=DCACHE_rdata_i[18] DCACHE_rdata[17]=DCACHE_rdata_i[17]
+ DCACHE_rdata[16]=DCACHE_rdata_i[16] DCACHE_rdata[15]=DCACHE_rdata_i[15]
+ DCACHE_rdata[14]=DCACHE_rdata_i[14] DCACHE_rdata[13]=DCACHE_rdata_i[13]
+ DCACHE_rdata[12]=DCACHE_rdata_i[12] DCACHE_rdata[11]=DCACHE_rdata_i[11]
+ DCACHE_rdata[10]=DCACHE_rdata_i[10] DCACHE_rdata[9]=DCACHE_rdata_i[9]
+ DCACHE_rdata[8]=DCACHE_rdata_i[8] DCACHE_rdata[7]=DCACHE_rdata_i[7]
+ DCACHE_rdata[6]=DCACHE_rdata_i[6] DCACHE_rdata[5]=DCACHE_rdata_i[5]
+ DCACHE_rdata[4]=DCACHE_rdata_i[4] DCACHE_rdata[3]=DCACHE_rdata_i[3]
+ DCACHE_rdata[2]=DCACHE_rdata_i[2] DCACHE_rdata[1]=DCACHE_rdata_i[1]
+ DCACHE_rdata[0]=DCACHE_rdata_i[0] DCACHE_ren=DCACHE_ren_i
+ DCACHE_wen=DCACHE_wen_i DCACHE_wdata[31]=DCACHE_wdata_i[31]
+ DCACHE_wdata[30]=DCACHE_wdata_i[30] DCACHE_wdata[29]=DCACHE_wdata_i[29]
+ DCACHE_wdata[28]=DCACHE_wdata_i[28] DCACHE_wdata[27]=DCACHE_wdata_i[27]
+ DCACHE_wdata[26]=DCACHE_wdata_i[26] DCACHE_wdata[25]=DCACHE_wdata_i[25]
+ DCACHE_wdata[24]=DCACHE_wdata_i[24] DCACHE_wdata[23]=DCACHE_wdata_i[23]
+ DCACHE_wdata[22]=DCACHE_wdata_i[22] DCACHE_wdata[21]=DCACHE_wdata_i[21]
+ DCACHE_wdata[20]=DCACHE_wdata_i[20] DCACHE_wdata[19]=DCACHE_wdata_i[19]
+ DCACHE_wdata[18]=DCACHE_wdata_i[18] DCACHE_wdata[17]=DCACHE_wdata_i[17]
+ DCACHE_wdata[16]=DCACHE_wdata_i[16] DCACHE_wdata[15]=DCACHE_wdata_i[15]
+ DCACHE_wdata[14]=DCACHE_wdata_i[14] DCACHE_wdata[13]=DCACHE_wdata_i[13]
+ DCACHE_wdata[12]=DCACHE_wdata_i[12] DCACHE_wdata[11]=DCACHE_wdata_i[11]
+ DCACHE_wdata[10]=DCACHE_wdata_i[10] DCACHE_wdata[9]=DCACHE_wdata_i[9]
+ DCACHE_wdata[8]=DCACHE_wdata_i[8] DCACHE_wdata[7]=DCACHE_wdata_i[7]
+ DCACHE_wdata[6]=DCACHE_wdata_i[6] DCACHE_wdata[5]=DCACHE_wdata_i[5]
+ DCACHE_wdata[4]=DCACHE_wdata_i[4] DCACHE_wdata[3]=DCACHE_wdata_i[3]
+ DCACHE_wdata[2]=DCACHE_wdata_i[2] DCACHE_wdata[1]=DCACHE_wdata_i[1]
+ DCACHE_wdata[0]=DCACHE_wdata_i[0] DCACHE_stall=DCACHE_stall_i test_si=test_si_i
+ test_so=test_so_i test_se=test_se_i clk_i__L3_N1=clk_i__L3_N1
+ clk_i__L3_N10=clk_i__L3_N10 clk_i__L3_N11=clk_i__L3_N11
+ clk_i__L3_N12=clk_i__L3_N12 clk_i__L3_N13=clk_i__L3_N13
+ clk_i__L3_N14=clk_i__L3_N14 clk_i__L3_N15=clk_i__L3_N15
+ clk_i__L3_N16=clk_i__L3_N16 clk_i__L3_N17=clk_i__L3_N17
+ clk_i__L3_N18=clk_i__L3_N18 clk_i__L3_N19=clk_i__L3_N19
+ clk_i__L3_N2=clk_i__L3_N2 clk_i__L3_N20=clk_i__L3_N20
+ clk_i__L3_N21=clk_i__L3_N21 clk_i__L3_N22=clk_i__L3_N22
+ clk_i__L3_N23=clk_i__L3_N23 clk_i__L3_N24=clk_i__L3_N24
+ clk_i__L3_N25=clk_i__L3_N25 clk_i__L3_N26=clk_i__L3_N26
+ clk_i__L3_N27=clk_i__L3_N27 clk_i__L3_N3=clk_i__L3_N3 clk_i__L3_N4=clk_i__L3_N4
+ clk_i__L3_N5=clk_i__L3_N5 clk_i__L3_N6=clk_i__L3_N6 clk_i__L3_N7=clk_i__L3_N7
+ clk_i__L3_N8=clk_i__L3_N8 clk_i__L3_N9=clk_i__L3_N9
.ENDS
.GLOBAL VDD
.GLOBAL VSS
