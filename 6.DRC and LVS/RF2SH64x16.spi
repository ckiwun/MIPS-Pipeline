$ Spice netlist generated by v2lvs
$ v2012.2_26.20    Thu Jun 14 12:01:04 PDT 2012

.SUBCKT RF2SH64x16 QA[15] QA[14] QA[13] QA[12] QA[11] QA[10] QA[9] QA[8] QA[7]
+ QA[6] QA[5] QA[4] QA[3] QA[2] QA[1] QA[0] DB[15] DB[14] DB[13] DB[12] DB[11]
+ DB[10] DB[9] DB[8] DB[7] DB[6] DB[5] DB[4] DB[3] DB[2] DB[1] DB[0] CLKB CLKA
+ CENB CENA AB[5] AB[4] AB[3] AB[2] AB[1] AB[0] AA[5] AA[4] AA[3] AA[2] AA[1]
+ AA[0]
.ENDS
